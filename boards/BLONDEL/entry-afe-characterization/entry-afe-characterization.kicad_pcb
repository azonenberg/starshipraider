# Repository azonenberg/starshipraider (continued)

## KiCad design boards/MAXWELL/maxwell-main/maxwell-main.kicad_pcb (continued)

Schematic: iofpga.sch, MAXWELL Main Board

Parts:
C37, C40: 100 uF; EIA_1210_CAP_NOSILK
C38, C44, C46, C47, C53, C58, C62, C63: 4.7 uF; EIA_0603_CAP_NOSILK
C39: 47 uF; EIA_0805_CAP_NOSILK
C41, C42, C43, C45, C48, C49, C50, C51, C52, C54, C55, C56, C57, C59, C60, C61, C64: 0.47 uF; EIA_0402_CAP_NOSILK
J2: XILINX_JTAG; XILINX_JTAG_PTH_MOLEX_0878311420
R25, R28, R248, R249, R250: 4.7K; EIA_0402_RES_NOSILK
R26, R27, R29, R30, R31, R32: 33; EIA_0402_RES_NOSILK
TP11, TP12, TP13, TP14: TESTPAD; TESTPOINT_SMT_0.5MM
U4: XC7S6-1FTGB196C; BGA_196_15x15_FULLARRAY_1MM_FTGB196
U29: S25FL128LAGNFV010; DFN_8_1.27MM_6x5MM

Connections:
/1V0_1: C37.1, C38.1, C44.1, C45.1, C51.1, U4.D6 (VCCINT), U4.D8 (VCCINT), U4.E5 (VCCBRAM), U4.E7 (VCCINT), U4.E9 (VCCINT), U4.F6 (VCCINT), U4.G5 (VCCBRAM), U4.G9 (VCCINT), U4.H6 (VCCINT), U4.J5 (VCCBRAM), U4.J9 (VCCINT), U4.K6 (VCCINT), U4.K8 (VCCINT); also elsewhere on the board
/1V8: C39.1, C46.1, C52.1, C57.1, U4.B8 (VCCBATT_0), U4.F8 (VCCADC_0), U4.F10 (VCCAUX), U4.H10 (VCCAUX), U4.K10 (VCCAUX), U4.L9 (VCCAUX); also elsewhere on the board
/3V3: C40.1, C41.1, C42.1, C43.1, C47.1, C48.1, C49.1, C50.1, C53.1, C54.1, C55.1, C56.1, C58.1, C59.1, C60.1, C61.1, C62.1, C63.1, C64.1, J2.2 (Vccaux), R25.2, R28.1, R248.1, R249.1, R250.1, U4.G2 (VCCO_34), U4.G13 (VCCO_14), U4.K2 (VCCO_34), U4.K13 (VCCO_14), U4.M7 (M0_0), U4.N2 (VCCO_34), U4.N6 (VCCO_0), U4.N7 (CFGBVS_0), U4.N8 (VCCO_0), U4.N13 (VCCO_14), U29.8 (VCC); also elsewhere on the board
/GND: C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, J2.3 (Vss), J2.5 (Vss), J2.7 (Vss), J2.9 (Vss), J2.11 (Vss), TP11.1, U4.A1 (GND), U4.A6 (GND), U4.A9 (GND), U4.A11 (GND), U4.A14 (GND), U4.B4 (GND), U4.B7 (GND), U4.B9 (GND), U4.C2 (GND), U4.C6 (GND), U4.C7 (GND), U4.C8 (GND), U4.C9 (GND), U4.C13 (GND), U4.D5 (GND), U4.D7 (GND), U4.D9 (GND), U4.D11 (GND), U4.E1 (GND), U4.E3 (GND), U4.E6 (GND), U4.E8 (GND), U4.E10 (GND), U4.E14 (GND), U4.F5 (GND), U4.F7 (GNDADC_0), U4.F9 (GND), U4.G3 (GND), U4.G6 (GND), U4.G7 (VREFN_0), U4.G8 (VP_0), U4.G10 (GND), U4.G12 (GND), U4.H5 (GND), U4.H7 (VN_0), U4.H8 (VREFP_0), U4.H9 (GND), U4.J6 (GND), U4.J7 (DXN_0), U4.J8 (DXP_0), U4.J10 (GND), U4.K1 (GND), U4.K5 (GND), U4.K7 (GND), U4.K9 (GND), U4.K14 (GND), U4.L4 (GND), U4.L6 (GND), U4.L8 (GND), U4.L10 (GND), U4.L11 (GND), U4.M8 (M1_0), U4.M9 (M2_0), U4.N3 (GND), U4.N5 (GND), U4.N9 (GND), U4.N12 (GND), U4.P1 (GND), U4.P14 (GND), U29.4 (GND); also elsewhere on the board
/Inputs/IO FPGA/S7_QSPI_SCK: R27.1, U29.6 (CLK)
/Inputs/IO FPGA/S7_TCK: J2.6 (TCK), U4.A7 (TCK_0)
/Inputs/IO FPGA/S7_TDI: J2.10 (TDI_OUT), U4.P7 (TDI_0)
/Inputs/IO FPGA/S7_TDO: J2.8 (TDO_IN), R26.2
/Inputs/IO FPGA/S7_TMS: J2.4 (TMS), U4.M6 (TMS_0)
/Inputs/S7_DONE: TP14.1, U4.P9 (DONE_0); also elsewhere on the board
/Inputs/S7_INIT_B: R28.2, TP13.1, U4.P8 (INIT_B_0); also elsewhere on the board
/Inputs/S7_QSPI_CS_N: R248.2, U29.1 (CS#); also elsewhere on the board
/Inputs/S7_QSPI_DQ0: R32.1; also elsewhere on the board
/Inputs/S7_QSPI_DQ1: R29.2; also elsewhere on the board
/Inputs/S7_QSPI_DQ2: R30.2, R249.2; also elsewhere on the board
/Inputs/S7_QSPI_DQ3: R31.1, R250.2; also elsewhere on the board
/Inputs/S7_RST_N: R25.1, TP12.1, U4.L7 (PROGRAM_B_0); also elsewhere on the board
unnamed: R26.1, U4.P6 (TDO_0)
unnamed: R27.2, U4.A8 (CCLK_0)
unnamed: R29.1, U29.2 (DO/IO1)
unnamed: R30.1, U29.3 (WP#/IO2)
unnamed: R31.2, U29.7 (HOLD#/IO3)
unnamed: R32.2, U29.5 (DI/IO0)

Notes on the sheet:
VCCINT decoupling
VCCBRAM decoupling
VCCAUX decoupling
VCCO decoupling

Schematic: rightpods.sch, MAXWELL Main Board

Parts:
D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D30, D31, D32: ESD7008
J3, J4, J5, J6, J7, J8: CONN_SFF8087; CONN_SFF8087_MOLEX_75783-0140
U2: XC7K160T-2FFG676C; BGA_676_27x27_FULLARRAY_1MM_FFG676

Connections:
/Clocking/K7_CLK_N: U2.D10 (IO_L12N_T1_MRCC_16); also elsewhere on the board
/Clocking/K7_CLK_P: U2.E10 (IO_L12P_T1_MRCC_16); also elsewhere on the board
/Clocking/TRIG_OUT_N: U2.A10 (IO_L22N_T3_16); also elsewhere on the board
/Clocking/TRIG_OUT_P: U2.B10 (IO_L22P_T3_16); also elsewhere on the board
/GND: D2.3 (GND), D2.6 (GND), D2.9 (GND), D2.13 (GND), D2.15 (GND), D2.17 (GND), D3.3 (GND), D3.6 (GND), D3.9 (GND), D3.13 (GND), D3.15 (GND), D3.17 (GND), D4.3 (GND), D4.6 (GND), D4.9 (GND), D4.13 (GND), D4.15 (GND), D4.17 (GND), D5.3 (GND), D5.6 (GND), D5.9 (GND), D5.13 (GND), D5.15 (GND), D5.17 (GND), D6.3 (GND), D6.6 (GND), D6.9 (GND), D6.13 (GND), D6.15 (GND), D6.17 (GND), D7.3 (GND), D7.6 (GND), D7.9 (GND), D7.13 (GND), D7.15 (GND), D7.17 (GND), D8.3 (GND), D8.6 (GND), D8.9 (GND), D8.13 (GND), D8.15 (GND), D8.17 (GND), D9.3 (GND), D9.6 (GND), D9.9 (GND), D9.13 (GND), D9.15 (GND), D9.17 (GND), D10.3 (GND), D10.6 (GND), D10.9 (GND), D10.13 (GND), D10.15 (GND), D10.17 (GND), D11.3 (GND), D11.6 (GND), D11.9 (GND), D11.13 (GND), D11.15 (GND), D11.17 (GND), D12.3 (GND), D12.6 (GND), D12.9 (GND), D12.13 (GND), D12.15 (GND), D12.17 (GND), D13.3 (GND), D13.6 (GND), D13.9 (GND), D13.13 (GND), D13.15 (GND), D13.17 (GND), D30.3 (GND), D30.6 (GND), D30.9 (GND), D30.13 (GND), D30.15 (GND), D30.17 (GND), D31.3 (GND), D31.6 (GND), D31.9 (GND), D31.13 (GND), D31.15 (GND), D31.17 (GND), D32.3 (GND), D32.6 (GND), D32.9 (GND), D32.13 (GND), D32.15 (GND), D32.17 (GND), J3.A1 (GND), J3.A4 (GND), J3.A7 (GND), J3.A12 (GND), J3.A15 (GND), J3.A18 (GND), J3.B1 (GND), J3.B4 (GND), J3.B7 (GND), J3.B12 (GND), J3.B15 (GND), J3.B18 (GND), J3.SHLD (GND), J4.A1 (GND), J4.A4 (GND), J4.A7 (GND), J4.A12 (GND), J4.A15 (GND), J4.A18 (GND), J4.B1 (GND), J4.B4 (GND), J4.B7 (GND), J4.B12 (GND), J4.B15 (GND), J4.B18 (GND), J4.SHLD (GND), J5.A1 (GND), J5.A4 (GND), J5.A7 (GND), J5.A12 (GND), J5.A15 (GND), J5.A18 (GND), J5.B1 (GND), J5.B4 (GND), J5.B7 (GND), J5.B12 (GND), J5.B15 (GND), J5.B18 (GND), J5.SHLD (GND), J6.A1 (GND), J6.A4 (GND), J6.A7 (GND), J6.A12 (GND), J6.A15 (GND), J6.A18 (GND), J6.B1 (GND), J6.B4 (GND), J6.B7 (GND), J6.B12 (GND), J6.B15 (GND), J6.B18 (GND), J6.SHLD (GND), J7.A1 (GND), J7.A4 (GND), J7.A7 (GND), J7.A12 (GND), J7.A15 (GND), J7.A18 (GND), J7.B1 (GND), J7.B4 (GND), J7.B7 (GND), J7.B12 (GND), J7.B15 (GND), J7.B18 (GND), J7.SHLD (GND), J8.A1 (GND), J8.A4 (GND), J8.A7 (GND), J8.A12 (GND), J8.A15 (GND), J8.A18 (GND), J8.B1 (GND), J8.B4 (GND), J8.B7 (GND), J8.B12 (GND), J8.B15 (GND), J8.B18 (GND), J8.SHLD (GND); also elsewhere on the board
/Inputs/P6_UART_RX: D30.1 (IO), J3.A8 (SB6); also elsewhere on the board
/Inputs/P6_UART_TX: D30.2 (IO), J3.A9 (SB3); also elsewhere on the board
/Inputs/P7_UART_RX: D30.8 (IO), J4.A8 (SB6); also elsewhere on the board
/Inputs/P7_UART_TX: D30.10 (IO), J4.A9 (SB3); also elsewhere on the board
/Inputs/P8_UART_RX: D31.1 (IO), J5.A8 (SB6); also elsewhere on the board
/Inputs/P8_UART_TX: D31.2 (IO), J5.A9 (SB3); also elsewhere on the board
/Inputs/P9_UART_RX: D31.8 (IO), J6.A8 (SB6); also elsewhere on the board
/Inputs/P9_UART_TX: D31.10 (IO), J6.A9 (SB3); also elsewhere on the board
/Inputs/P10_UART_RX: D32.1 (IO), J7.A8 (SB6); also elsewhere on the board
/Inputs/P10_UART_TX: D32.2 (IO), J7.A9 (SB3); also elsewhere on the board
/Inputs/P11_UART_RX: D32.8 (IO), J8.A8 (SB6); also elsewhere on the board
/Inputs/P11_UART_TX: D32.10 (IO), J8.A9 (SB3); also elsewhere on the board
/Inputs/Pod Power/P6_PRESENT: D30.4 (IO), J3.A10 (SB4); also elsewhere on the board
/Inputs/Pod Power/P7_PRESENT: D30.11 (IO), J4.A10 (SB4); also elsewhere on the board
/Inputs/Pod Power/P8_PRESENT: D31.4 (IO), J5.A10 (SB4); also elsewhere on the board
/Inputs/Pod Power/P9_PRESENT: D31.11 (IO), J6.A10 (SB4); also elsewhere on the board
/Inputs/Pod Power/P10_PRESENT: D32.4 (IO), J7.A10 (SB4); also elsewhere on the board
/Inputs/Pod Power/P11_PRESENT: D32.11 (IO), J8.A10 (SB4); also elsewhere on the board
/Inputs/Right Pods/MUX0_EQ: U2.J14 (IO_25_16); also elsewhere on the board
/Inputs/Right Pods/MUX0_SEL: U2.J8 (IO_0_16); also elsewhere on the board
/Inputs/Right Pods/MUX1_EQ: U2.M16 (IO_25_15); also elsewhere on the board
/Inputs/Right Pods/MUX1_SEL: U2.K15 (IO_0_15); also elsewhere on the board
/Inputs/Right Pods/MUX2_EQ: U2.A15 (IO_L23N_T3_16); also elsewhere on the board
/Inputs/Right Pods/MUX2_SEL: U2.B15 (IO_L23P_T3_16); also elsewhere on the board
/Inputs/Right Pods/MUX3_EQ: U2.A12 (IO_L24N_T3_16); also elsewhere on the board
/Inputs/Right Pods/MUX3_SEL: U2.A13 (IO_L24P_T3_16); also elsewhere on the board
/Inputs/Right Pods/P6_12V0: J3.A11 (SB5), J3.B8 (SB0), J3.B9 (SB1), J3.B10 (SB2), J3.B11 (SB7); also elsewhere on the board
/Inputs/Right Pods/P7_12V0: J4.A11 (SB5), J4.B8 (SB0), J4.B9 (SB1), J4.B10 (SB2), J4.B11 (SB7); also elsewhere on the board
/Inputs/Right Pods/P8_12V0: J5.A11 (SB5), J5.B8 (SB0), J5.B9 (SB1), J5.B10 (SB2), J5.B11 (SB7); also elsewhere on the board
/Inputs/Right Pods/P9_12V0: J6.A11 (SB5), J6.B8 (SB0), J6.B9 (SB1), J6.B10 (SB2), J6.B11 (SB7); also elsewhere on the board
/Inputs/Right Pods/P10_12V0: J7.A11 (SB5), J7.B8 (SB0), J7.B9 (SB1), J7.B10 (SB2), J7.B11 (SB7); also elsewhere on the board
/Inputs/Right Pods/P11_12V0: J8.A11 (SB5), J8.B8 (SB0), J8.B9 (SB1), J8.B10 (SB2), J8.B11 (SB7); also elsewhere on the board
/Inputs/Right Pods/POD6_D0_N: D2.2 (IO), J3.B3 (TX0_N), U2.F18 (IO_L11N_T1_SRCC_AD12N_15)
/Inputs/Right Pods/POD6_D0_P: D2.1 (IO), J3.B2 (TX0_P), U2.G17 (IO_L11P_T1_SRCC_AD12P_15)
/Inputs/Right Pods/POD6_D1_N: D2.5 (IO), J3.B6 (TX1_N), U2.B16 (IO_L1N_T0_AD0N_15)
/Inputs/Right Pods/POD6_D1_P: D2.4 (IO), J3.B5 (TX1_P), U2.C16 (IO_L1P_T0_AD0P_15)
/Inputs/Right Pods/POD6_D2_N: D2.8 (IO), J3.B14 (TX2_N), U2.A19 (IO_L2N_T0_AD8N_15)
/Inputs/Right Pods/POD6_D2_P: D2.7 (IO), J3.B13 (TX2_P), U2.A18 (IO_L2P_T0_AD8P_15)
/Inputs/Right Pods/POD6_D3_N: D2.11 (IO), J3.B17 (TX3_N), U2.A17 (IO_L3N_T0_DQS_AD1N_15)
/Inputs/Right Pods/POD6_D3_P: D2.10 (IO), J3.B16 (TX3_P), U2.B17 (IO_L3P_T0_DQS_AD1P_15)
/Inputs/Right Pods/POD6_D4_N: D3.10 (IO), J3.A3 (RX0_N), U2.B19 (IO_L4N_T0_AD9N_15)
/Inputs/Right Pods/POD6_D4_P: D3.11 (IO), J3.A2 (RX0_P), U2.C19 (IO_L4P_T0_AD9P_15)
/Inputs/Right Pods/POD6_D5_N: D3.7 (IO), J3.A6 (RX1_N), U2.C18 (IO_L5N_T0_AD2N_15)
/Inputs/Right Pods/POD6_D5_P: D3.8 (IO), J3.A5 (RX1_P), U2.C17 (IO_L5P_T0_AD2P_15)
/Inputs/Right Pods/POD6_D6_N: D3.4 (IO), J3.A14 (RX2_N), U2.D16 (IO_L6N_T0_VREF_15)
/Inputs/Right Pods/POD6_D6_P: D3.5 (IO), J3.A13 (RX2_P), U2.D15 (IO_L6P_T0_15)
/Inputs/Right Pods/POD6_D7_N: D3.1 (IO), J3.A17 (RX3_N), U2.G16 (IO_L7N_T1_AD10N_15)
/Inputs/Right Pods/POD6_D7_P: D3.2 (IO), J3.A16 (RX3_P), U2.H16 (IO_L7P_T1_AD10P_15)
/Inputs/Right Pods/POD7_D0_N: D4.2 (IO), J4.B3 (TX0_N), U2.E17 (IO_L12N_T1_MRCC_AD5N_15)
/Inputs/Right Pods/POD7_D0_P: D4.1 (IO), J4.B2 (TX0_P), U2.F17 (IO_L12P_T1_MRCC_AD5P_15)
/Inputs/Right Pods/POD7_D1_N: D4.5 (IO), J4.B6 (TX1_N), U2.F15 (IO_L8N_T1_AD3N_15)
/Inputs/Right Pods/POD7_D1_P: D4.4 (IO), J4.B5 (TX1_P), U2.G15 (IO_L8P_T1_AD3P_15)
/Inputs/Right Pods/POD7_D2_N: D4.8 (IO), J4.B14 (TX2_N), U2.J16 (IO_L9N_T1_DQS_AD11N_15)
/Inputs/Right Pods/POD7_D2_P: D4.7 (IO), J4.B13 (TX2_P), U2.J15 (IO_L9P_T1_DQS_AD11P_15)
/Inputs/Right Pods/POD7_D3_N: D4.11 (IO), J4.B17 (TX3_N), U2.E16 (IO_L10N_T1_AD4N_15)
/Inputs/Right Pods/POD7_D3_P: D4.10 (IO), J4.B16 (TX3_P), U2.E15 (IO_L10P_T1_AD4P_15)
/Inputs/Right Pods/POD7_D4_N: D5.10 (IO), J4.A3 (RX0_N), U2.H18 (IO_L14N_T2_SRCC_15)
/Inputs/Right Pods/POD7_D4_P: D5.11 (IO), J4.A2 (RX0_P), U2.H17 (IO_L14P_T2_SRCC_15)
/Inputs/Right Pods/POD7_D5_N: D5.7 (IO), J4.A6 (RX1_N), U2.D20 (IO_L15N_T2_DQS_ADV_B_15)
/Inputs/Right Pods/POD7_D5_P: D5.8 (IO), J4.A5 (RX1_P), U2.D19 (IO_L15P_T2_DQS_15)
/Inputs/Right Pods/POD7_D6_N: D5.4 (IO), J4.A14 (RX2_N), U2.F20 (IO_L16N_T2_A27_15)
/Inputs/Right Pods/POD7_D6_P: D5.5 (IO), J4.A13 (RX2_P), U2.G19 (IO_L16P_T2_A28_15)
/Inputs/Right Pods/POD7_D7_N: D5.1 (IO), J4.A17 (RX3_N), U2.E20 (IO_L17N_T2_A25_15)
/Inputs/Right Pods/POD7_D7_P: D5.2 (IO), J4.A16 (RX3_P), U2.F19 (IO_L17P_T2_A26_15)
/Inputs/Right Pods/POD8_D0_N: D6.2 (IO), J5.B3 (TX0_N), U2.D18 (IO_L13N_T2_MRCC_15)
/Inputs/Right Pods/POD8_D0_P: D6.1 (IO), J5.B2 (TX0_P), U2.E18 (IO_L13P_T2_MRCC_15)
/Inputs/Right Pods/POD8_D1_N: D6.5 (IO), J5.B6 (TX1_N), U2.G20 (IO_L18N_T2_A23_15)
/Inputs/Right Pods/POD8_D1_P: D6.4 (IO), J5.B5 (TX1_P), U2.H19 (IO_L18P_T2_A24_15)
/Inputs/Right Pods/POD8_D2_N: D6.8 (IO), J5.B14 (TX2_N), U2.J20 (IO_L19N_T3_A21_VREF_15)
/Inputs/Right Pods/POD8_D2_P: D6.7 (IO), J5.B13 (TX2_P), U2.K20 (IO_L19P_T3_A22_15)
/Inputs/Right Pods/POD8_D3_N: D6.11 (IO), J5.B17 (TX3_N), U2.J19 (IO_L20N_T3_A19_15)
/Inputs/Right Pods/POD8_D3_P: D6.10 (IO), J5.B16 (TX3_P), U2.J18 (IO_L20P_T3_A20_15)
/Inputs/Right Pods/POD8_D4_N: D7.10 (IO), J5.A3 (RX0_N), U2.L20 (IO_L21N_T3_DQS_A18_15)
/Inputs/Right Pods/POD8_D4_P: D7.11 (IO), J5.A2 (RX0_P), U2.L19 (IO_L21P_T3_DQS_15)
/Inputs/Right Pods/POD8_D5_N: D7.7 (IO), J5.A6 (RX1_N), U2.K17 (IO_L22N_T3_A16_15)
/Inputs/Right Pods/POD8_D5_P: D7.8 (IO), J5.A5 (RX1_P), U2.K16 (IO_L22P_T3_A17_15)
/Inputs/Right Pods/POD8_D6_N: D7.4 (IO), J5.A14 (RX2_N), U2.L18 (IO_L23N_T3_FWE_B_15)
/Inputs/Right Pods/POD8_D6_P: D7.5 (IO), J5.A13 (RX2_P), U2.M17 (IO_L23P_T3_FOE_B_15)
/Inputs/Right Pods/POD8_D7_N: D7.1 (IO), J5.A17 (RX3_N), U2.K18 (IO_L24N_T3_RS0_15)
/Inputs/Right Pods/POD8_D7_P: D7.2 (IO), J5.A16 (RX3_P), U2.L17 (IO_L24P_T3_RS1_15)
/Inputs/Right Pods/POD9_D0_N: D8.2 (IO), J6.B3 (TX0_N), U2.F10 (IO_L11N_T1_SRCC_16)
/Inputs/Right Pods/POD9_D0_P: D8.1 (IO), J6.B2 (TX0_P), U2.G11 (IO_L11P_T1_SRCC_16)
/Inputs/Right Pods/POD9_D1_N: D8.5 (IO), J6.B6 (TX1_N), U2.H8 (IO_L1N_T0_16)
/Inputs/Right Pods/POD9_D1_P: D8.4 (IO), J6.B5 (TX1_P), U2.H9 (IO_L1P_T0_16)
/Inputs/Right Pods/POD9_D2_N: D8.8 (IO), J6.B14 (TX2_N), U2.G9 (IO_L2N_T0_16)
/Inputs/Right Pods/POD9_D2_P: D8.7 (IO), J6.B13 (TX2_P), U2.G10 (IO_L2P_T0_16)
/Inputs/Right Pods/POD9_D3_N: D8.11 (IO), J6.B17 (TX3_N), U2.H13 (IO_L3N_T0_DQS_16)
/Inputs/Right Pods/POD9_D3_P: D8.10 (IO), J6.B16 (TX3_P), U2.J13 (IO_L3P_T0_DQS_16)
/Inputs/Right Pods/POD9_D4_N: D9.10 (IO), J6.A3 (RX0_N), U2.J10 (IO_L4N_T0_16)
/Inputs/Right Pods/POD9_D4_P: D9.11 (IO), J6.A2 (RX0_P), U2.J11 (IO_L4P_T0_16)
/Inputs/Right Pods/POD9_D5_N: D9.7 (IO), J6.A6 (RX1_N), U2.G14 (IO_L5N_T0_16)
/Inputs/Right Pods/POD9_D5_P: D9.8 (IO), J6.A5 (RX1_P), U2.H14 (IO_L5P_T0_16)
/Inputs/Right Pods/POD9_D6_N: D9.4 (IO), J6.A14 (RX2_N), U2.H11 (IO_L6N_T0_VREF_16)
/Inputs/Right Pods/POD9_D6_P: D9.5 (IO), J6.A13 (RX2_P), U2.H12 (IO_L6P_T0_16)
/Inputs/Right Pods/POD9_D7_N: D9.1 (IO), J6.A17 (RX3_N), U2.F8 (IO_L7N_T1_16)
/Inputs/Right Pods/POD9_D7_P: D9.2 (IO), J6.A16 (RX3_P), U2.F9 (IO_L7P_T1_16)
/Inputs/Right Pods/POD10_D0_N: D10.2 (IO), J7.B3 (TX0_N), U2.C11 (IO_L13N_T2_MRCC_16)
/Inputs/Right Pods/POD10_D0_P: D10.1 (IO), J7.B2 (TX0_P), U2.C12 (IO_L13P_T2_MRCC_16)
/Inputs/Right Pods/POD10_D1_N: D10.5 (IO), J7.B6 (TX1_N), U2.D8 (IO_L8N_T1_16)
/Inputs/Right Pods/POD10_D1_P: D10.4 (IO), J7.B5 (TX1_P), U2.D9 (IO_L8P_T1_16)
/Inputs/Right Pods/POD10_D2_N: D10.8 (IO), J7.B14 (TX2_N), U2.A8 (IO_L9N_T1_DQS_16)
/Inputs/Right Pods/POD10_D2_P: D10.7 (IO), J7.B13 (TX2_P), U2.A9 (IO_L9P_T1_DQS_16)
/Inputs/Right Pods/POD10_D3_N: D10.11 (IO), J7.B17 (TX3_N), U2.B9 (IO_L10N_T1_16)
/Inputs/Right Pods/POD10_D3_P: D10.10 (IO), J7.B16 (TX3_P), U2.C9 (IO_L10P_T1_16)
/Inputs/Right Pods/POD10_D4_N: D11.10 (IO), J7.A3 (RX0_N), U2.F13 (IO_L15N_T2_DQS_16)
/Inputs/Right Pods/POD10_D4_P: D11.11 (IO), J7.A2 (RX0_P), U2.F14 (IO_L15P_T2_DQS_16)
/Inputs/Right Pods/POD10_D5_N: D11.7 (IO), J7.A6 (RX1_N), U2.F12 (IO_L16N_T2_16)
/Inputs/Right Pods/POD10_D5_P: D11.8 (IO), J7.A5 (RX1_P), U2.G12 (IO_L16P_T2_16)
/Inputs/Right Pods/POD10_D6_N: D11.4 (IO), J7.A14 (RX2_N), U2.D13 (IO_L17N_T2_16)
/Inputs/Right Pods/POD10_D6_P: D11.5 (IO), J7.A13 (RX2_P), U2.D14 (IO_L17P_T2_16)
/Inputs/Right Pods/POD10_D7_N: D11.1 (IO), J7.A17 (RX3_N), U2.E12 (IO_L18N_T2_16)
/Inputs/Right Pods/POD10_D7_P: D11.2 (IO), J7.A16 (RX3_P), U2.E13 (IO_L18P_T2_16)
/Inputs/Right Pods/POD11_D0_N: D12.2 (IO), J8.B3 (TX0_N), U2.D11 (IO_L14N_T2_SRCC_16)
/Inputs/Right Pods/POD11_D0_P: D12.1 (IO), J8.B2 (TX0_P), U2.E11 (IO_L14P_T2_SRCC_16)
/Inputs/Right Pods/POD11_D1_N: D12.5 (IO), J8.B6 (TX1_N), U2.C13 (IO_L19N_T3_VREF_16)
/Inputs/Right Pods/POD11_D1_P: D12.4 (IO), J8.B5 (TX1_P), U2.C14 (IO_L19P_T3_16)
/Inputs/Right Pods/POD11_D2_N: D12.8 (IO), J8.B14 (TX2_N), U2.B11 (IO_L20N_T3_16)
/Inputs/Right Pods/POD11_D2_P: D12.7 (IO), J8.B13 (TX2_P), U2.B12 (IO_L20P_T3_16)
/Inputs/Right Pods/POD11_D3_N: D12.11 (IO), J8.B17 (TX3_N), U2.A14 (IO_L21N_T3_DQS_16)
/Inputs/Right Pods/POD11_D3_P: D12.10 (IO), J8.B16 (TX3_P), U2.B14 (IO_L21P_T3_DQS_16)
/Inputs/Right Pods/POD11_D4_N: D13.10 (IO), J8.A3 (RX0_N); also elsewhere on the board
/Inputs/Right Pods/POD11_D4_P: D13.11 (IO), J8.A2 (RX0_P); also elsewhere on the board
/Inputs/Right Pods/POD11_D5_N: D13.7 (IO), J8.A6 (RX1_N); also elsewhere on the board
/Inputs/Right Pods/POD11_D5_P: D13.8 (IO), J8.A5 (RX1_P); also elsewhere on the board
/Inputs/Right Pods/POD11_D6_N: D13.4 (IO), J8.A14 (RX2_N); also elsewhere on the board
/Inputs/Right Pods/POD11_D6_P: D13.5 (IO), J8.A13 (RX2_P); also elsewhere on the board
/Inputs/Right Pods/POD11_D7_N: D13.1 (IO), J8.A17 (RX3_N); also elsewhere on the board
/Inputs/Right Pods/POD11_D7_P: D13.2 (IO), J8.A16 (RX3_P); also elsewhere on the board

Schematic: leftpods.sch, MAXWELL Main Board

Parts:
D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D33, D34, D35: ESD7008
J15, J16, J17, J18, J19, J20: CONN_SFF8087; CONN_SFF8087_MOLEX_75783-0140
TP15, TP16: TESTCLIP; TESTPOINT_SMT_KEYSTONE_5016
TP17: Conn_01x04; CONN_HEADER_2.54MM_1x4
U2: XC7K160T-2FFG676C; BGA_676_27x27_FULLARRAY_1MM_FFG676

Connections:
/GND: D14.3 (GND), D14.6 (GND), D14.9 (GND), D14.13 (GND), D14.15 (GND), D14.17 (GND), D15.3 (GND), D15.6 (GND), D15.9 (GND), D15.13 (GND), D15.15 (GND), D15.17 (GND), D16.3 (GND), D16.6 (GND), D16.9 (GND), D16.13 (GND), D16.15 (GND), D16.17 (GND), D17.3 (GND), D17.6 (GND), D17.9 (GND), D17.13 (GND), D17.15 (GND), D17.17 (GND), D18.3 (GND), D18.6 (GND), D18.9 (GND), D18.13 (GND), D18.15 (GND), D18.17 (GND), D19.3 (GND), D19.6 (GND), D19.9 (GND), D19.13 (GND), D19.15 (GND), D19.17 (GND), D20.3 (GND), D20.6 (GND), D20.9 (GND), D20.13 (GND), D20.15 (GND), D20.17 (GND), D21.3 (GND), D21.6 (GND), D21.9 (GND), D21.13 (GND), D21.15 (GND), D21.17 (GND), D22.3 (GND), D22.6 (GND), D22.9 (GND), D22.13 (GND), D22.15 (GND), D22.17 (GND), D23.3 (GND), D23.6 (GND), D23.9 (GND), D23.13 (GND), D23.15 (GND), D23.17 (GND), D24.3 (GND), D24.6 (GND), D24.9 (GND), D24.13 (GND), D24.15 (GND), D24.17 (GND), D25.3 (GND), D25.6 (GND), D25.9 (GND), D25.13 (GND), D25.15 (GND), D25.17 (GND), D33.3 (GND), D33.6 (GND), D33.9 (GND), D33.13 (GND), D33.15 (GND), D33.17 (GND), D34.3 (GND), D34.6 (GND), D34.9 (GND), D34.13 (GND), D34.15 (GND), D34.17 (GND), D35.3 (GND), D35.6 (GND), D35.9 (GND), D35.13 (GND), D35.15 (GND), D35.17 (GND), J15.A1 (GND), J15.A4 (GND), J15.A7 (GND), J15.A12 (GND), J15.A15 (GND), J15.A18 (GND), J15.B1 (GND), J15.B4 (GND), J15.B7 (GND), J15.B12 (GND), J15.B15 (GND), J15.B18 (GND), J15.SHLD (GND), J16.A1 (GND), J16.A4 (GND), J16.A7 (GND), J16.A12 (GND), J16.A15 (GND), J16.A18 (GND), J16.B1 (GND), J16.B4 (GND), J16.B7 (GND), J16.B12 (GND), J16.B15 (GND), J16.B18 (GND), J16.SHLD (GND), J17.A1 (GND), J17.A4 (GND), J17.A7 (GND), J17.A12 (GND), J17.A15 (GND), J17.A18 (GND), J17.B1 (GND), J17.B4 (GND), J17.B7 (GND), J17.B12 (GND), J17.B15 (GND), J17.B18 (GND), J17.SHLD (GND), J18.A1 (GND), J18.A4 (GND), J18.A7 (GND), J18.A12 (GND), J18.A15 (GND), J18.A18 (GND), J18.B1 (GND), J18.B4 (GND), J18.B7 (GND), J18.B12 (GND), J18.B15 (GND), J18.B18 (GND), J18.SHLD (GND), J19.A1 (GND), J19.A4 (GND), J19.A7 (GND), J19.A12 (GND), J19.A15 (GND), J19.A18 (GND), J19.B1 (GND), J19.B4 (GND), J19.B7 (GND), J19.B12 (GND), J19.B15 (GND), J19.B18 (GND), J19.SHLD (GND), J20.A1 (GND), J20.A4 (GND), J20.A7 (GND), J20.A12 (GND), J20.A15 (GND), J20.A18 (GND), J20.B1 (GND), J20.B4 (GND), J20.B7 (GND), J20.B12 (GND), J20.B15 (GND), J20.B18 (GND), J20.SHLD (GND), TP15.1, TP17.4; also elsewhere on the board
/Inputs/Left Pods/P0_12V0: J15.A11 (SB5), J15.B8 (SB0), J15.B9 (SB1), J15.B10 (SB2), J15.B11 (SB7), TP16.1; also elsewhere on the board
/Inputs/Left Pods/P1_12V0: J16.A11 (SB5), J16.B8 (SB0), J16.B9 (SB1), J16.B10 (SB2), J16.B11 (SB7); also elsewhere on the board
/Inputs/Left Pods/P2_12V0: J17.A11 (SB5), J17.B8 (SB0), J17.B9 (SB1), J17.B10 (SB2), J17.B11 (SB7); also elsewhere on the board
/Inputs/Left Pods/P3_12V0: J18.A11 (SB5), J18.B8 (SB0), J18.B9 (SB1), J18.B10 (SB2), J18.B11 (SB7); also elsewhere on the board
/Inputs/Left Pods/P4_12V0: J19.A11 (SB5), J19.B8 (SB0), J19.B9 (SB1), J19.B10 (SB2), J19.B11 (SB7); also elsewhere on the board
/Inputs/Left Pods/P5_12V0: J20.A11 (SB5), J20.B8 (SB0), J20.B9 (SB1), J20.B10 (SB2), J20.B11 (SB7); also elsewhere on the board
/Inputs/Left Pods/POD0_D0_N: D14.2 (IO), J15.B3 (TX0_N), U2.AB24 (IO_L11N_T1_SRCC_12)
/Inputs/Left Pods/POD0_D0_P: D14.1 (IO), J15.B2 (TX0_P), U2.AA23 (IO_L11P_T1_SRCC_12)
/Inputs/Left Pods/POD0_D1_N: D14.5 (IO), J15.B6 (TX1_N), U2.V22 (IO_L1N_T0_12)
/Inputs/Left Pods/POD0_D1_P: D14.4 (IO), J15.B5 (TX1_P), U2.U22 (IO_L1P_T0_12)
/Inputs/Left Pods/POD0_D2_N: D14.8 (IO), J15.B14 (TX2_N), U2.U25 (IO_L2N_T0_12)
/Inputs/Left Pods/POD0_D2_P: D14.7 (IO), J15.B13 (TX2_P), U2.U24 (IO_L2P_T0_12)
/Inputs/Left Pods/POD0_D3_N: D14.11 (IO), J15.B17 (TX3_N), U2.V24 (IO_L3N_T0_DQS_12)
/Inputs/Left Pods/POD0_D3_P: D14.10 (IO), J15.B16 (TX3_P), U2.V23 (IO_L3P_T0_DQS_12)
/Inputs/Left Pods/POD0_D4_N: D15.10 (IO), J15.A3 (RX0_N), U2.V26 (IO_L4N_T0_12)
/Inputs/Left Pods/POD0_D4_P: D15.11 (IO), J15.A2 (RX0_P), U2.U26 (IO_L4P_T0_12)
/Inputs/Left Pods/POD0_D5_N: D15.7 (IO), J15.A6 (RX1_N), U2.W26 (IO_L5N_T0_12)
/Inputs/Left Pods/POD0_D5_P: D15.8 (IO), J15.A5 (RX1_P), U2.W25 (IO_L5P_T0_12)
/Inputs/Left Pods/POD0_D6_N: D15.4 (IO), J15.A14 (RX2_N), U2.W21 (IO_L6N_T0_VREF_12)
/Inputs/Left Pods/POD0_D6_P: D15.5 (IO), J15.A13 (RX2_P), U2.V21 (IO_L6P_T0_12)
/Inputs/Left Pods/POD0_D7_N: D15.1 (IO), J15.A17 (RX3_N), U2.AB25 (IO_L7N_T1_12)
/Inputs/Left Pods/POD0_D7_P: D15.2 (IO), J15.A16 (RX3_P), U2.AA25 (IO_L7P_T1_12)
/Inputs/Left Pods/POD1_D0_N: D16.2 (IO), J16.B3 (TX0_N), U2.AA24 (IO_L12N_T1_MRCC_12)
/Inputs/Left Pods/POD1_D0_P: D16.1 (IO), J16.B2 (TX0_P), U2.Y23 (IO_L12P_T1_MRCC_12)
/Inputs/Left Pods/POD1_D1_N: D16.5 (IO), J16.B6 (TX1_N), U2.W24 (IO_L8N_T1_12)
/Inputs/Left Pods/POD1_D1_P: D16.4 (IO), J16.B5 (TX1_P), U2.W23 (IO_L8P_T1_12)
/Inputs/Left Pods/POD1_D2_N: D16.8 (IO), J16.B14 (TX2_N), U2.AC26 (IO_L9N_T1_DQS_12)
/Inputs/Left Pods/POD1_D2_P: D16.7 (IO), J16.B13 (TX2_P), U2.AB26 (IO_L9P_T1_DQS_12)
/Inputs/Left Pods/POD1_D3_N: D16.11 (IO), J16.B17 (TX3_N), U2.Y26 (IO_L10N_T1_12)
/Inputs/Left Pods/POD1_D3_P: D16.10 (IO), J16.B16 (TX3_P), U2.Y25 (IO_L10P_T1_12)
/Inputs/Left Pods/POD1_D4_N: D17.10 (IO), J16.A3 (RX0_N), U2.AC24 (IO_L14N_T2_SRCC_12)
/Inputs/Left Pods/POD1_D4_P: D17.11 (IO), J16.A2 (RX0_P), U2.AC23 (IO_L14P_T2_SRCC_12)
/Inputs/Left Pods/POD1_D5_N: D17.7 (IO), J16.A6 (RX1_N), U2.Y21 (IO_L15N_T2_DQS_12)
/Inputs/Left Pods/POD1_D5_P: D17.8 (IO), J16.A5 (RX1_P), U2.W20 (IO_L15P_T2_DQS_12)
/Inputs/Left Pods/POD1_D6_N: D17.4 (IO), J16.A14 (RX2_N), U2.AD24 (IO_L16N_T2_12)
/Inputs/Left Pods/POD1_D6_P: D17.5 (IO), J16.A13 (RX2_P), U2.AD23 (IO_L16P_T2_12)
/Inputs/Left Pods/POD1_D7_N: D17.1 (IO), J16.A17 (RX3_N), U2.AC22 (IO_L17N_T2_12)
/Inputs/Left Pods/POD1_D7_P: D17.2 (IO), J16.A16 (RX3_P), U2.AB22 (IO_L17P_T2_12)
/Inputs/Left Pods/POD2_D0_N: D18.2 (IO), J17.B3 (TX0_N), U2.AA22 (IO_L13N_T2_MRCC_12)
/Inputs/Left Pods/POD2_D0_P: D18.1 (IO), J17.B2 (TX0_P), U2.Y22 (IO_L13P_T2_MRCC_12)
/Inputs/Left Pods/POD2_D1_N: D18.5 (IO), J17.B6 (TX1_N), U2.AC21 (IO_L18N_T2_12)
/Inputs/Left Pods/POD2_D1_P: D18.4 (IO), J17.B5 (TX1_P), U2.AB21 (IO_L18P_T2_12)
/Inputs/Left Pods/POD2_D2_N: D18.8 (IO), J17.B14 (TX2_N), U2.AE21 (IO_L19N_T3_VREF_12)
/Inputs/Left Pods/POD2_D2_P: D18.7 (IO), J17.B13 (TX2_P), U2.AD21 (IO_L19P_T3_12)
/Inputs/Left Pods/POD2_D3_N: D18.11 (IO), J17.B17 (TX3_N), U2.AF25 (IO_L20N_T3_12)
/Inputs/Left Pods/POD2_D3_P: D18.10 (IO), J17.B16 (TX3_P), U2.AF24 (IO_L20P_T3_12)
/Inputs/Left Pods/POD2_D4_N: D19.10 (IO), J17.A3 (RX0_N), U2.AE26 (IO_L21N_T3_DQS_12)
/Inputs/Left Pods/POD2_D4_P: D19.11 (IO), J17.A2 (RX0_P), U2.AD26 (IO_L21P_T3_DQS_12)
/Inputs/Left Pods/POD2_D5_N: D19.7 (IO), J17.A6 (RX1_N), U2.AF23 (IO_L22N_T3_12)
/Inputs/Left Pods/POD2_D5_P: D19.8 (IO), J17.A5 (RX1_P), U2.AE23 (IO_L22P_T3_12)
/Inputs/Left Pods/POD2_D6_N: D19.4 (IO), J17.A14 (RX2_N), U2.AE25 (IO_L23N_T3_12)
/Inputs/Left Pods/POD2_D6_P: D19.5 (IO), J17.A13 (RX2_P), U2.AD25 (IO_L23P_T3_12)
/Inputs/Left Pods/POD2_D7_N: D19.1 (IO), J17.A17 (RX3_N), U2.AF22 (IO_L24N_T3_12)
/Inputs/Left Pods/POD2_D7_P: D19.2 (IO), J17.A16 (RX3_P), U2.AE22 (IO_L24P_T3_12)
/Inputs/Left Pods/POD3_D0_N: D20.2 (IO), J18.B3 (TX0_N), U2.N23 (IO_L11N_T1_SRCC_13)
/Inputs/Left Pods/POD3_D0_P: D20.1 (IO), J18.B2 (TX0_P), U2.P23 (IO_L11P_T1_SRCC_13)
/Inputs/Left Pods/POD3_D1_N: D20.5 (IO), J18.B6 (TX1_N), U2.K26 (IO_L1N_T0_13)
/Inputs/Left Pods/POD3_D1_P: D20.4 (IO), J18.B5 (TX1_P), U2.K25 (IO_L1P_T0_13)
/Inputs/Left Pods/POD3_D2_N: D20.8 (IO), J18.B14 (TX2_N), U2.P26 (IO_L2N_T0_13)
/Inputs/Left Pods/POD3_D2_P: D20.7 (IO), J18.B13 (TX2_P), U2.R26 (IO_L2P_T0_13)
/Inputs/Left Pods/POD3_D3_N: D20.11 (IO), J18.B17 (TX3_N), U2.L25 (IO_L3N_T0_DQS_13)
/Inputs/Left Pods/POD3_D3_P: D20.10 (IO), J18.B16 (TX3_P), U2.M25 (IO_L3P_T0_DQS_13)
/Inputs/Left Pods/POD3_D4_N: D21.10 (IO), J18.A3 (RX0_N), U2.N24 (IO_L4N_T0_13)
/Inputs/Left Pods/POD3_D4_P: D21.11 (IO), J18.A2 (RX0_P), U2.P24 (IO_L4P_T0_13)
/Inputs/Left Pods/POD3_D5_N: D21.7 (IO), J18.A6 (RX1_N), U2.M26 (IO_L5N_T0_13)
/Inputs/Left Pods/POD3_D5_P: D21.8 (IO), J18.A5 (RX1_P), U2.N26 (IO_L5P_T0_13)
/Inputs/Left Pods/POD3_D6_N: D21.4 (IO), J18.A14 (RX2_N), U2.P25 (IO_L6N_T0_VREF_13)
/Inputs/Left Pods/POD3_D6_P: D21.5 (IO), J18.A13 (RX2_P), U2.R25 (IO_L6P_T0_13)
/Inputs/Left Pods/POD3_D7_N: D21.1 (IO), J18.A17 (RX3_N), U2.M20 (IO_L7N_T1_13)
/Inputs/Left Pods/POD3_D7_P: D21.2 (IO), J18.A16 (RX3_P), U2.N19 (IO_L7P_T1_13)
/Inputs/Left Pods/POD4_D0_N: D22.2 (IO), J19.B3 (TX0_N), U2.N22 (IO_L12N_T1_MRCC_13)
/Inputs/Left Pods/POD4_D0_P: D22.1 (IO), J19.B2 (TX0_P), U2.N21 (IO_L12P_T1_MRCC_13)
/Inputs/Left Pods/POD4_D1_N: D22.5 (IO), J19.B6 (TX1_N), U2.L24 (IO_L8N_T1_13)
/Inputs/Left Pods/POD4_D1_P: D22.4 (IO), J19.B5 (TX1_P), U2.M24 (IO_L8P_T1_13)
/Inputs/Left Pods/POD4_D2_N: D22.8 (IO), J19.B14 (TX2_N), U2.P20 (IO_L9N_T1_DQS_13)
/Inputs/Left Pods/POD4_D2_P: D22.7 (IO), J19.B13 (TX2_P), U2.P19 (IO_L9P_T1_DQS_13)
/Inputs/Left Pods/POD4_D3_N: D22.11 (IO), J19.B17 (TX3_N), U2.M22 (IO_L10N_T1_13)
/Inputs/Left Pods/POD4_D3_P: D22.10 (IO), J19.B16 (TX3_P), U2.M21 (IO_L10P_T1_13)
/Inputs/Left Pods/POD4_D4_N: D23.10 (IO), J19.A3 (RX0_N), U2.R23 (IO_L14N_T2_SRCC_13)
/Inputs/Left Pods/POD4_D4_P: D23.11 (IO), J19.A2 (RX0_P), U2.R22 (IO_L14P_T2_SRCC_13)
/Inputs/Left Pods/POD4_D5_N: D23.7 (IO), J19.A6 (RX1_N), U2.T25 (IO_L15N_T2_DQS_13)
/Inputs/Left Pods/POD4_D5_P: D23.8 (IO), J19.A5 (RX1_P), U2.T24 (IO_L15P_T2_DQS_13)
/Inputs/Left Pods/POD4_D6_N: D23.4 (IO), J19.A14 (RX2_N), U2.R20 (IO_L16N_T2_13)
/Inputs/Left Pods/POD4_D6_P: D23.5 (IO), J19.A13 (RX2_P), U2.T20 (IO_L16P_T2_13)
/Inputs/Left Pods/POD4_D7_N: D23.1 (IO), J19.A17 (RX3_N), U2.T23 (IO_L17N_T2_13)
/Inputs/Left Pods/POD4_D7_P: D23.2 (IO), J19.A16 (RX3_P), U2.T22 (IO_L17P_T2_13)
/Inputs/Left Pods/POD5_D0_N: D24.2 (IO), J20.B3 (TX0_N), U2.P21 (IO_L13N_T2_MRCC_13)
/Inputs/Left Pods/POD5_D0_P: D24.1 (IO), J20.B2 (TX0_P), U2.R21 (IO_L13P_T2_MRCC_13)
/Inputs/Left Pods/POD5_D1_N: D24.5 (IO), J20.B6 (TX1_N), U2.U20 (IO_L18N_T2_13)
/Inputs/Left Pods/POD5_D1_P: D24.4 (IO), J20.B5 (TX1_P), U2.U19 (IO_L18P_T2_13)
/Inputs/Left Pods/POD5_D2_N: D24.8 (IO), J20.B14 (TX2_N), U2.T19 (IO_L19N_T3_VREF_13)
/Inputs/Left Pods/POD5_D2_P: D24.7 (IO), J20.B13 (TX2_P), U2.T18 (IO_L19P_T3_13)
/Inputs/Left Pods/POD5_D3_N: D24.11 (IO), J20.B17 (TX3_N), U2.N17 (IO_L20N_T3_13)
/Inputs/Left Pods/POD5_D3_P: D24.10 (IO), J20.B16 (TX3_P), U2.P16 (IO_L20P_T3_13)
/Inputs/Left Pods/POD5_D4_N: D25.10 (IO), J20.A3 (RX0_N), U2.R17 (IO_L21N_T3_DQS_13)
/Inputs/Left Pods/POD5_D4_P: D25.11 (IO), J20.A2 (RX0_P), U2.R16 (IO_L21P_T3_DQS_13)
/Inputs/Left Pods/POD5_D5_N: D25.7 (IO), J20.A6 (RX1_N), U2.M19 (IO_L22N_T3_13)
/Inputs/Left Pods/POD5_D5_P: D25.8 (IO), J20.A5 (RX1_P), U2.N18 (IO_L22P_T3_13)
/Inputs/Left Pods/POD5_D6_N: D25.4 (IO), J20.A14 (RX2_N), U2.T17 (IO_L23N_T3_13)
/Inputs/Left Pods/POD5_D6_P: D25.5 (IO), J20.A13 (RX2_P), U2.U17 (IO_L23P_T3_13)
/Inputs/Left Pods/POD5_D7_N: D25.1 (IO), J20.A17 (RX3_N), U2.P18 (IO_L24N_T3_13)
/Inputs/Left Pods/POD5_D7_P: D25.2 (IO), J20.A16 (RX3_P), U2.R18 (IO_L24P_T3_13)
/Inputs/P0_PRESENT: D33.4 (IO), J15.A10 (SB4), TP17.1; also elsewhere on the board
/Inputs/P0_UART_RX: D33.1 (IO), J15.A8 (SB6), TP17.3; also elsewhere on the board
/Inputs/P0_UART_TX: D33.2 (IO), J15.A9 (SB3), TP17.2; also elsewhere on the board
/Inputs/P1_PRESENT: D33.11 (IO), J16.A10 (SB4); also elsewhere on the board
/Inputs/P1_UART_RX: D33.8 (IO), J16.A8 (SB6); also elsewhere on the board
/Inputs/P1_UART_TX: D33.10 (IO), J16.A9 (SB3); also elsewhere on the board
/Inputs/P2_PRESENT: D34.4 (IO), J17.A10 (SB4); also elsewhere on the board
/Inputs/P2_UART_RX: D34.1 (IO), J17.A8 (SB6); also elsewhere on the board
/Inputs/P2_UART_TX: D34.2 (IO), J17.A9 (SB3); also elsewhere on the board
/Inputs/P3_PRESENT: D34.11 (IO), J18.A10 (SB4); also elsewhere on the board
/Inputs/P3_UART_RX: D34.8 (IO), J18.A8 (SB6); also elsewhere on the board
/Inputs/P3_UART_TX: D34.10 (IO), J18.A9 (SB3); also elsewhere on the board
/Inputs/P4_PRESENT: D35.4 (IO), J19.A10 (SB4); also elsewhere on the board
/Inputs/P4_UART_RX: D35.1 (IO), J19.A8 (SB6); also elsewhere on the board
/Inputs/P4_UART_TX: D35.2 (IO), J19.A9 (SB3); also elsewhere on the board
/Inputs/P5_PRESENT: D35.11 (IO), J20.A10 (SB4); also elsewhere on the board
/Inputs/P5_UART_RX: D35.8 (IO), J20.A8 (SB6); also elsewhere on the board
/Inputs/P5_UART_TX: D35.10 (IO), J20.A9 (SB3); also elsewhere on the board

Schematic: podpower.sch, MAXWELL Main Board

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C424, C425, C426, C427, C428, C429, C430, C431, C432, C433, C434, C435: 0.47 uF; EIA_0402_CAP_NOSILK
C13, C14: 22 uF 25V; EIA_1812_CAP_NOSILK; Part 445-1607-1-ND
C15, C16, C17, C18, C25, C26, C27, C28, C29, C30: 22 uF 25V; EIA_1812_CAP_NOSILK
C19, C20, C21, C22, C23, C24, C31, C32, C33, C34, C35, C36: DNP; EIA_0402_CAP_NOSILK
F1, F2, F3, F4, F5, F6, F7, F8, F9, F10, F11, F12: 1A; EIA_0402_RES_NOSILK
R1, R2, R3, R4, R5, R6, R13, R14, R15, R16, R17, R18: 1K; EIA_0402_RES_NOSILK
R7, R8, R9, R10, R11, R12, R19, R20, R21, R22, R23, R24: 50m; EIA_0603_RES_NOSILK
R107, R108, R109, R110, R111, R112: 100K; EIA_0402_RES_NOSILK
TP9, TP10: TESTCLIP; TESTPOINT_SMT_KEYSTONE_5016
U4: XC7S6-1FTGB196C; BGA_196_15x15_FULLARRAY_1MM_FTGB196
U5, U6, U7, U8, U9, U10, U11, U12, U13, U14, U15, U16: INA233; SOP_10_0.5MM_3MM
U17, U18, U19, U20, U21, U22, U23, U24, U25, U26, U27, U28: NCP45525IMNTWG-H; DFN_8_0.5MM_2x2MM

Connections:
/3V3: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C424.1, C425.1, C426.1, C427.1, C428.1, C429.1, C430.1, C431.1, C432.1, C433.1, C434.1, C435.1, R107.1, R108.1, R109.1, R110.1, R111.1, R112.1, U5.6 (Vs+), U6.2 (A0), U6.6 (Vs+), U7.6 (Vs+), U8.6 (Vs+), U9.1 (A1), U9.6 (Vs+), U10.1 (A1), U10.2 (A0), U10.6 (Vs+), U11.1 (A1), U11.6 (Vs+), U12.1 (A1), U12.6 (Vs+), U13.6 (Vs+), U14.2 (A0), U14.6 (Vs+), U15.6 (Vs+), U16.6 (Vs+), U17.3 (VCC), U18.3 (VCC), U19.3 (VCC), U20.3 (VCC), U21.3 (VCC), U22.3 (VCC), U23.3 (VCC), U24.3 (VCC), U25.3 (VCC), U26.3 (VCC), U27.3 (VCC), U28.3 (VCC); also elsewhere on the board
/12V0: C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, TP10.1, U17.1 (VIN), U17.PAD (VIN), U18.1 (VIN), U18.PAD (VIN), U19.1 (VIN), U19.PAD (VIN), U20.1 (VIN), U20.PAD (VIN), U21.1 (VIN), U21.PAD (VIN), U22.1 (VIN), U22.PAD (VIN), U23.1 (VIN), U23.PAD (VIN), U24.1 (VIN), U24.PAD (VIN), U25.1 (VIN), U25.PAD (VIN), U26.1 (VIN), U26.PAD (VIN), U27.1 (VIN), U27.PAD (VIN), U28.1 (VIN), U28.PAD (VIN); also elsewhere on the board
/GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C424.2, C425.2, C426.2, C427.2, C428.2, C429.2, C430.2, C431.2, C432.2, C433.2, C434.2, C435.2, U5.1 (A1), U5.2 (A0), U5.7 (GND), U6.1 (A1), U6.7 (GND), U7.1 (A1), U7.7 (GND), U8.1 (A1), U8.7 (GND), U9.2 (A0), U9.7 (GND), U10.7 (GND), U11.7 (GND), U12.7 (GND), U13.2 (A0), U13.7 (GND), U14.7 (GND), U15.7 (GND), U16.7 (GND), U17.4 (GND), U18.4 (GND), U19.4 (GND), U20.4 (GND), U21.4 (GND), U22.4 (GND), U23.4 (GND), U24.4 (GND), U25.4 (GND), U26.4 (GND), U27.4 (GND), U28.4 (GND); also elsewhere on the board
/Inputs/I2C1_SCL: U5.5 (SCL), U6.5 (SCL), U7.5 (SCL), U8.2 (A0), U8.5 (SCL), U9.5 (SCL), U10.5 (SCL), U11.5 (SCL), U12.2 (A0), U12.5 (SCL), U13.5 (SCL), U14.5 (SCL), U15.5 (SCL), U16.2 (A0), U16.5 (SCL); also elsewhere on the board
/Inputs/I2C1_SDA: U5.4 (SDA), U6.4 (SDA), U7.2 (A0), U7.4 (SDA), U8.4 (SDA), U9.4 (SDA), U10.4 (SDA), U11.2 (A0), U11.4 (SDA), U12.4 (SDA), U13.1 (A1), U13.4 (SDA), U14.1 (A1), U14.4 (SDA), U15.1 (A1), U15.2 (A0), U15.4 (SDA), U16.1 (A1), U16.4 (SDA); also elsewhere on the board
/Inputs/P0_PWREN: TP9.1, U17.2 (EN); also elsewhere on the board
/Inputs/P1_PWREN: U18.2 (EN); also elsewhere on the board
/Inputs/P2_PWREN: U19.2 (EN); also elsewhere on the board
/Inputs/P3_PWREN: U20.2 (EN); also elsewhere on the board
/Inputs/P4_PWREN: U21.2 (EN); also elsewhere on the board
/Inputs/P5_PWREN: U22.2 (EN); also elsewhere on the board
/Inputs/P6_UART_RX: U4.A4 (IO_L2P_T0_34); also elsewhere on the board
/Inputs/P6_UART_TX: U4.B3 (IO_L3P_T0_DQS_34); also elsewhere on the board
/Inputs/P7_UART_RX: U4.C3 (IO_L1N_T0_34); also elsewhere on the board
/Inputs/P7_UART_TX: U4.B2 (IO_L5P_T0_34); also elsewhere on the board
/Inputs/P8_UART_RX: U4.D1 (IO_L11P_T1_SRCC_34); also elsewhere on the board
/Inputs/P8_UART_TX: U4.E4 (IO_L7P_T1_34); also elsewhere on the board
/Inputs/P9_UART_RX: U4.G1 (IO_L9P_T1_DQS_34); also elsewhere on the board
/Inputs/P9_UART_TX: U4.H2 (IO_L14P_T2_SRCC_34); also elsewhere on the board
/Inputs/P10_UART_RX: U4.H1 (IO_L14N_T2_SRCC_34); also elsewhere on the board
/Inputs/P10_UART_TX: U4.J4 (IO_L17P_T2_34); also elsewhere on the board
/Inputs/P11_UART_RX: U4.J1 (IO_L15N_T2_DQS_34); also elsewhere on the board
/Inputs/P11_UART_TX: U4.K4 (IO_L16P_T2_34); also elsewhere on the board
/Inputs/Pod Power/P0_12V0: R7.1, U5.8 (Vbus), U5.9 (Vin-); also elsewhere on the board
/Inputs/Pod Power/P0_ALERT: U4.A5 (IO_L4N_T0_34), U5.3 (Alert)
/Inputs/Pod Power/P0_VSHUNT: F1.2, R7.2, U5.10 (Vin+)
/Inputs/Pod Power/P1_12V0: R8.1, U6.8 (Vbus), U6.9 (Vin-); also elsewhere on the board
/Inputs/Pod Power/P1_ALERT: U4.B6 (IO_0_34), U6.3 (Alert)
/Inputs/Pod Power/P1_VSHUNT: F2.2, R8.2, U6.10 (Vin+)
/Inputs/Pod Power/P2_12V0: R9.1, U7.8 (Vbus), U7.9 (Vin-); also elsewhere on the board
/Inputs/Pod Power/P2_ALERT: U4.B5 (IO_L4P_T0_34), U7.3 (Alert)
/Inputs/Pod Power/P2_VSHUNT: F3.2, R9.2, U7.10 (Vin+)
/Inputs/Pod Power/P3_12V0: R10.1, U8.8 (Vbus), U8.9 (Vin-); also elsewhere on the board
/Inputs/Pod Power/P3_ALERT: U4.C5 (IO_L6P_T0_34), U8.3 (Alert)
/Inputs/Pod Power/P3_VSHUNT: F4.2, R10.2, U8.10 (Vin+)
/Inputs/Pod Power/P4_12V0: R11.1, U9.8 (Vbus), U9.9 (Vin-); also elsewhere on the board
/Inputs/Pod Power/P4_ALERT: U4.C4 (IO_L6N_T0_VREF_34), U9.3 (Alert)
/Inputs/Pod Power/P4_VSHUNT: F5.2, R11.2, U9.10 (Vin+)
/Inputs/Pod Power/P5_12V0: R12.1, U10.8 (Vbus), U10.9 (Vin-); also elsewhere on the board
/Inputs/Pod Power/P5_ALERT: U4.D4 (IO_L7N_T1_34), U10.3 (Alert)
/Inputs/Pod Power/P5_VSHUNT: F6.2, R12.2, U10.10 (Vin+)
/Inputs/Pod Power/P6_12V0: R19.1, U11.8 (Vbus), U11.9 (Vin-); also elsewhere on the board
/Inputs/Pod Power/P6_ALERT: U4.D3 (IO_L1P_T0_34), U11.3 (Alert)
/Inputs/Pod Power/P6_PRESENT: R107.2, U4.A3 (IO_L2N_T0_34); also elsewhere on the board
/Inputs/Pod Power/P6_PWREN: U4.L3 (IO_L22P_T3_34), U23.2 (EN)
/Inputs/Pod Power/P6_VSHUNT: F7.2, R19.2, U11.10 (Vin+)
/Inputs/Pod Power/P7_12V0: R20.1, U12.8 (Vbus), U12.9 (Vin-); also elsewhere on the board
/Inputs/Pod Power/P7_ALERT: U4.D2 (IO_L10N_T1_34), U12.3 (Alert)
/Inputs/Pod Power/P7_PRESENT: R108.2, U4.A2 (IO_L3N_T0_DQS_34); also elsewhere on the board
/Inputs/Pod Power/P7_PWREN: U4.C1 (IO_L11N_T1_SRCC_34), U24.2 (EN)
/Inputs/Pod Power/P7_VSHUNT: F8.2, R20.2, U12.10 (Vin+)
/Inputs/Pod Power/P8_12V0: R21.1, U13.8 (Vbus), U13.9 (Vin-); also elsewhere on the board
/Inputs/Pod Power/P8_ALERT: U4.E2 (IO_L10P_T1_34), U13.3 (Alert)
/Inputs/Pod Power/P8_PRESENT: R109.2, U4.F1 (IO_L9N_T1_DQS_34); also elsewhere on the board
/Inputs/Pod Power/P8_PWREN: U4.B1 (IO_L5N_T0_34), U25.2 (EN)
/Inputs/Pod Power/P8_VSHUNT: F9.2, R21.2, U13.10 (Vin+)
/Inputs/Pod Power/P9_12V0: R22.1, U14.8 (Vbus), U14.9 (Vin-); also elsewhere on the board
/Inputs/Pod Power/P9_ALERT: U4.F2 (IO_L8N_T1_34), U14.3 (Alert)
/Inputs/Pod Power/P9_PRESENT: R110.2, U4.J2 (IO_L15P_T2_DQS_34); also elsewhere on the board
/Inputs/Pod Power/P9_PWREN: U4.F3 (IO_L8P_T1_34), U26.2 (EN)
/Inputs/Pod Power/P9_VSHUNT: F10.2, R22.2, U14.10 (Vin+)
/Inputs/Pod Power/P10_12V0: R23.1, U15.8 (Vbus), U15.9 (Vin-); also elsewhere on the board
/Inputs/Pod Power/P10_ALERT: U4.G4 (IO_L12P_T1_MRCC_34), U15.3 (Alert)
/Inputs/Pod Power/P10_PRESENT: R111.2, U4.J3 (IO_L17N_T2_34); also elsewhere on the board
/Inputs/Pod Power/P10_PWREN: U4.H3 (IO_L13N_T2_MRCC_34), U27.2 (EN)
/Inputs/Pod Power/P10_VSHUNT: F11.2, R23.2, U15.10 (Vin+)
/Inputs/Pod Power/P11_12V0: R24.1, U16.8 (Vbus), U16.9 (Vin-); also elsewhere on the board
/Inputs/Pod Power/P11_ALERT: U4.F4 (IO_L12N_T1_MRCC_34), U16.3 (Alert)
/Inputs/Pod Power/P11_PRESENT: R112.2, U4.K3 (IO_L16N_T2_34); also elsewhere on the board
/Inputs/Pod Power/P11_PWREN: U4.H4 (IO_L13P_T2_MRCC_34), U28.2 (EN)
/Inputs/Pod Power/P11_VSHUNT: F12.2, R24.2, U16.10 (Vin+)
unnamed: C19.1, U17.6 (SR)
unnamed: C20.1, U18.6 (SR)
unnamed: C21.1, U19.6 (SR)
unnamed: C22.1, U20.6 (SR)
unnamed: C23.1, U21.6 (SR)
unnamed: C24.1, U22.6 (SR)
unnamed: C31.1, U23.6 (SR)
unnamed: C32.1, U24.6 (SR)
unnamed: C33.1, U25.6 (SR)
unnamed: C34.1, U26.6 (SR)
unnamed: C35.1, U27.6 (SR)
unnamed: C36.1, U28.6 (SR)
unnamed: F1.1, R1.1, U17.7 (VOUT), U17.8 (VOUT)
unnamed: F2.1, R2.1, U18.7 (VOUT), U18.8 (VOUT)
unnamed: F3.1, R3.1, U19.7 (VOUT), U19.8 (VOUT)
unnamed: F4.1, R4.1, U20.7 (VOUT), U20.8 (VOUT)
unnamed: F5.1, R5.1, U21.7 (VOUT), U21.8 (VOUT)
unnamed: F6.1, R6.1, U22.7 (VOUT), U22.8 (VOUT)
unnamed: F7.1, R13.1, U23.7 (VOUT), U23.8 (VOUT)
unnamed: F8.1, R14.1, U24.7 (VOUT), U24.8 (VOUT)
unnamed: F9.1, R15.1, U25.7 (VOUT), U25.8 (VOUT)
unnamed: F10.1, R16.1, U26.7 (VOUT), U26.8 (VOUT)
unnamed: F11.1, R17.1, U27.7 (VOUT), U27.8 (VOUT)
unnamed: F12.1, R18.1, U28.7 (VOUT), U28.8 (VOUT)
unnamed: R1.2, U17.5 (BLEED)
unnamed: R2.2, U18.5 (BLEED)
unnamed: R3.2, U19.5 (BLEED)
unnamed: R4.2, U20.5 (BLEED)
unnamed: R5.2, U21.5 (BLEED)
unnamed: R6.2, U22.5 (BLEED)
unnamed: R13.2, U23.5 (BLEED)
unnamed: R14.2, U24.5 (BLEED)
unnamed: R15.2, U25.5 (BLEED)
unnamed: R16.2, U26.5 (BLEED)
unnamed: R17.2, U27.5 (BLEED)
unnamed: R18.2, U28.5 (BLEED)

Notes on the sheet:
Bleed resistor is ~~100 ohms. Max safe power limit is 400 mW or 63 mA. 1K ohms gives ~~10 mA, which is well below safe limits. External resistor dissipates 100 mW, at the upper limit for an 0402, but only briefly during shutdown.
8'h80
8'h82
8'h84
8'h86
Load Switches
Current Monitoring
8'h88
8'h8a
8'h8c
8'h8e
8'h90
8'h92
8'h94
8'h9a
INA233 decoupling
50m @ 1A = 50 mW KDV06FR050ET is rated for 200
NCP45525 decoupling
