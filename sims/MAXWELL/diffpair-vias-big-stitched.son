diffpair-vias-big-stitched.son:
```
FTYP SONPROJ 17 ! Sonnet Project File
VER 17.52.2
HEADER
LIC antikernel2.2.49648 90e2ba8817c0 havequick azonenberg
DAT 08/13/2020 11:29:51
BUILT_BY_CREATED xgeom 16.56 07/03/2018 15:05:41
BUILT_BY_SAVED sonnet 17.52.2
MDATE 08/13/2020 11:29:51
HDATE 08/13/2020 11:29:51
END HEADER
DIM
ANG DEG
CAP PF
CON /OH
FREQ GHZ
IND NH
LNG MM
RES OH
END DIM
CONTROL
VARSWP
OPTIONS  -dj
SPEED 1
CACHE_ABS 1
Q_ACC N
END CONTROL
GEO
TMET "Free Space" 0 FREESPACE 376.7303136 0 0 0
BMET "Free Space" 0 FREESPACE 376.7303136 0 0 0
MET "Copper" 1 NOR 58000000 0.5 0.035 
MET "Copper" 1 VOL 58000000 20
BOX 8 27.7 10 2216 800 20 0
      1 1 1 0 0 0 0 "Air"
      0.1 3.66 1 0.0037 0 0 0 "Rogers_RO4350B"
      0.1 3.66 1 0.0037 0 0 0 "Rogers_RO4350B"
      0.254 3.66 1 0.0037 0 0 0 "Rogers_RO4350B"
      0.372 3.68 1 0.0092 0 0 0 "Isola_FR408HR"
      0.254 3.66 1 0.0037 0 0 0 "Rogers_RO4350B"
      0.1 3.66 1 0.0037 0 0 0 "Rogers_RO4350B"
      0.1 3.66 1 0.0037 0 0 0 "Rogers_RO4350B"
      1 1 1 0 0 0 0 "Air"
TECHLAY METAL Metal1 <UNSPECIFIED> -1 0 
0 0 0 N 0 1 1 100 100 0 0 0 Y
END
END
TECHLAY VIA Via1 <UNSPECIFIED> -9 0 
VIA POLYGON
0 0 1 N 0 1 1 100 100 0 0 0 Y
TOLEVEL 7 RING NOCOVERS
END
END
TECHLAY METAL Metal2 <UNSPECIFIED> -2 0 
1 0 0 N 0 1 1 100 100 0 0 0 Y
END
END
TECHLAY METAL Metal3 <UNSPECIFIED> -3 0 
2 0 0 N 0 1 1 100 100 0 0 0 Y
END
END
TECHLAY METAL Metal4 <UNSPECIFIED> -4 0 
3 0 0 N 0 1 1 100 100 0 0 0 Y
END
END
TECHLAY METAL Metal5 <UNSPECIFIED> -5 0 
4 0 0 N 0 1 1 100 100 0 0 0 Y
END
END
TECHLAY METAL Metal6 <UNSPECIFIED> -6 0 
5 0 0 N 0 1 1 100 100 0 0 0 Y
END
END
TECHLAY METAL Metal7 <UNSPECIFIED> -7 0 
6 0 0 N 0 1 1 100 100 0 0 0 Y
END
END
TECHLAY METAL Metal8 <UNSPECIFIED> -8 0 
7 0 0 N 0 1 1 100 100 0 0 0 Y
END
END
LORGN 0 5 U 
POR1 BOX
POLY 21 1
81
1 50 0 0 0 0.005 4.75 
POR1 BOX
POLY 23 1
57
3 50 0 0 0 0.005 5.25 
POR1 BOX
POLY 61 1
22
4 50 0 0 0 27.7 5.14 
POR1 BOX
POLY 63 1
12
2 50 0 0 0 27.7 4.86 
NUM 48
VIA POLYGON
0 65 1 N 12 1 1 100 100 0 0 0 Y
TOLEVEL 7 RING NOCOVERS
TLAYNAM Via1 INH
USER_DAT FromImport
11.012 3.8634
11 3.8628
10.988 3.861
10.976 3.858
10.964 3.8539
10.953 3.8486
10.943 3.8423
10.933 3.835
10.924 3.8268
10.915 3.8177
10.908 3.8078
10.902 3.7973
10.897 3.7862
10.892 3.7747
10.889 3.7628
10.888 3.7507
10.887 3.7384
10.888 3.7261
10.889 3.714
10.892 3.7021
10.897 3.6906
10.902 3.6795
10.908 3.669
10.915 3.6591
10.924 3.65
10.933 3.6418
10.943 3.6345
10.953 3.6282
10.964 3.6229
10.976 3.6188
10.988 3.6158
11 3.614
11.012 3.6134
11.024 3.614
11.036 3.6158
11.048 3.6188
11.06 3.6229
11.071 3.6282
11.081 3.6345
11.091 3.6418
11.1 3.65
11.109 3.6591
11.116 3.669
11.122 3.6795
11.127 3.6906
11.132 3.7021
11.135 3.714
11.136 3.7261
11.137 3.7384
11.136 3.7507
11.135 3.7628
11.132 3.7747
11.127 3.7862
11.122 3.7973
11.116 3.8078
11.109 3.8177
11.1 3.8268
11.091 3.835
11.081 3.8423
11.071 3.8486
11.06 3.8539
11.048 3.858
11.036 3.861
11.024 3.8628
11.012 3.8634
END
VIA POLYGON
0 65 1 N 13 1 1 100 100 0 0 0 Y
TOLEVEL 7 RING NOCOVERS
TLAYNAM Via1 INH
USER_DAT FromImport
11.005 6.375
10.993 6.3744
10.981 6.3726
10.969 6.3696
10.957 6.3655
10.946 6.3602
10.936 6.3539
10.926 6.3466
10.917 6.3384
10.908 6.3293
10.901 6.3194
10.895 6.3089
10.89 6.2978
10.885 6.2863
10.882 6.2744
10.881 6.2623
10.88 6.25
10.881 6.2377
10.882 6.2256
10.885 6.2137
10.89 6.2022
10.895 6.1911
10.901 6.1806
10.908 6.1707
10.917 6.1616
10.926 6.1534
10.936 6.1461
10.946 6.1398
10.957 6.1345
10.969 6.1304
10.981 6.1274
10.993 6.1256
11.005 6.125
11.017 6.1256
11.029 6.1274
11.041 6.1304
11.053 6.1345
11.064 6.1398
11.074 6.1461
11.084 6.1534
11.093 6.1616
11.102 6.1707
11.109 6.1806
11.115 6.1911
11.12 6.2022
11.125 6.2137
11.128 6.2256
11.129 6.2377
11.13 6.25
11.129 6.2623
11.128 6.2744
11.125 6.2863
11.12 6.2978
11.115 6.3089
11.109 6.3194
11.102 6.3293
11.093 6.3384
11.084 6.3466
11.074 6.3539
11.064 6.3602
11.053 6.3655
11.041 6.3696
11.029 6.3726
11.017 6.3744
11.005 6.375
END
0 65 0 N 14 1 1 100 100 0 0 0 Y
USER_DAT FromImport
0.492 6.2747
0.465 6.272
0.438 6.2668
0.412 6.2589
0.387 6.2486
0.364 6.2359
0.341 6.2209
0.32 6.2038
0.301 6.1847
0.284 6.1638
0.269 6.1414
0.256 6.1176
0.246 6.0926
0.238 6.0668
0.233 6.0404
0.23 6.0135
0.23 5.9865
0.233 5.9596
0.238 5.9332
0.246 5.9074
0.256 5.8824
0.269 5.8586
0.284 5.8362
0.301 5.8153
0.32 5.7962
0.341 5.7791
0.364 5.7641
0.387 5.7514
0.412 5.7411
0.438 5.7332
0.465 5.728
0.492 5.7253
0.518 5.7253
0.545 5.728
0.572 5.7332
0.598 5.7411
0.623 5.7514
0.646 5.7641
0.669 5.7791
0.69 5.7962
0.709 5.8153
0.726 5.8362
0.741 5.8586
0.754 5.8824
0.764 5.9074
0.772 5.9332
0.777 5.9596
0.78 5.9865
0.78 6.0135
0.777 6.0404
0.772 6.0668
0.764 6.0926
0.754 6.1176
0.741 6.1414
0.726 6.1638
0.709 6.1847
0.69 6.2038
0.669 6.2209
0.646 6.2359
0.623 6.2486
0.598 6.2589
0.572 6.2668
0.545 6.272
0.518 6.2747
0.492 6.2747
END
0 65 0 N 15 1 1 100 100 0 0 0 Y
USER_DAT FromImport
10.992 4.0247
10.965 4.022
10.938 4.0168
10.912 4.0089
10.887 3.9986
10.864 3.9859
10.841 3.9709
10.82 3.9538
10.801 3.9347
10.784 3.9138
10.769 3.8914
10.756 3.8676
10.746 3.8426
10.738 3.8168
10.733 3.7904
10.73 3.7635
10.73 3.7365
10.733 3.7096
10.738 3.6832
10.746 3.6574
10.756 3.6324
10.769 3.6086
10.784 3.5862
10.801 3.5653
10.82 3.5462
10.841 3.5291
10.864 3.5141
10.887 3.5014
10.912 3.4911
10.938 3.4832
10.965 3.478
10.992 3.4753
11.018 3.4753
11.045 3.478
11.072 3.4832
11.098 3.4911
11.123 3.5014
11.146 3.5141
11.169 3.5291
11.19 3.5462
11.209 3.5653
11.226 3.5862
11.241 3.6086
11.254 3.6324
11.264 3.6574
11.272 3.6832
11.277 3.7096
11.28 3.7365
11.28 3.7635
11.277 3.7904
11.272 3.8168
11.264 3.8426
11.254 3.8676
11.241 3.8914
11.226 3.9138
11.209 3.9347
11.19 3.9538
11.169 3.9709
11.146 3.9859
11.123 3.9986
11.098 4.0089
11.072 4.0168
11.045 4.022
11.018 4.0247
10.992 4.0247
END
0 65 0 N 16 1 1 100 100 0 0 0 Y
USER_DAT FromImport
10.992 6.5247
10.965 6.522
10.938 6.5168
10.912 6.5089
10.887 6.4986
10.864 6.4859
10.841 6.4709
10.82 6.4538
10.801 6.4347
10.784 6.4138
10.769 6.3914
10.756 6.3676
10.746 6.3426
10.738 6.3168
10.733 6.2904
10.73 6.2635
10.73 6.2365
10.733 6.2096
10.738 6.1832
10.746 6.1574
10.756 6.1324
10.769 6.1086
10.784 6.0862
10.801 6.0653
10.82 6.0462
10.841 6.0291
10.864 6.0141
10.887 6.0014
10.912 5.9911
10.938 5.9832
10.965 5.978
10.992 5.9753
11.018 5.9753
11.045 5.978
11.072 5.9832
11.098 5.9911
11.123 6.0014
11.146 6.0141
11.169 6.0291
11.19 6.0462
11.209 6.0653
11.226 6.0862
11.241 6.1086
11.254 6.1324
11.264 6.1574
11.272 6.1832
11.277 6.2096
11.28 6.2365
11.28 6.2635
11.277 6.2904
11.272 6.3168
11.264 6.3426
11.254 6.3676
11.241 6.3914
11.226 6.4138
11.209 6.4347
11.19 6.4538
11.169 6.4709
11.146 6.4859
11.123 6.4986
11.098 6.5089
11.072 6.5168
11.045 6.522
11.018 6.5247
10.992 6.5247
END
VIA POLYGON
0 65 1 N 17 1 1 100 100 0 0 0 Y
TOLEVEL 7 RING NOCOVERS
USER_DAT FromImport
0.505 3.375
0.493 3.3744
0.481 3.3726
0.469 3.3696
0.457 3.3655
0.446 3.3602
0.436 3.3539
0.426 3.3466
0.417 3.3384
0.408 3.3293
0.401 3.3194
0.395 3.3089
0.39 3.2978
0.385 3.2863
0.382 3.2744
0.381 3.2623
0.38 3.25
0.381 3.2377
0.382 3.2256
0.385 3.2137
0.39 3.2022
0.395 3.1911
0.401 3.1806
0.408 3.1707
0.417 3.1616
0.426 3.1534
0.436 3.1461
0.446 3.1398
0.457 3.1345
0.469 3.1304
0.481 3.1274
0.493 3.1256
0.505 3.125
0.517 3.1256
0.529 3.1274
0.541 3.1304
0.553 3.1345
0.564 3.1398
0.574 3.1461
0.584 3.1534
0.593 3.1616
0.602 3.1707
0.609 3.1806
0.615 3.1911
0.62 3.2022
0.625 3.2137
0.628 3.2256
0.629 3.2377
0.63 3.25
0.629 3.2623
0.628 3.2744
0.625 3.2863
0.62 3.2978
0.615 3.3089
0.609 3.3194
0.602 3.3293
0.593 3.3384
0.584 3.3466
0.574 3.3539
0.564 3.3602
0.553 3.3655
0.541 3.3696
0.529 3.3726
0.517 3.3744
0.505 3.375
END
VIA POLYGON
0 65 1 N 18 1 1 100 100 0 0 0 Y
TOLEVEL 7 RING NOCOVERS
USER_DAT FromImport
0.505 6.125
0.493 6.1244
0.481 6.1226
0.469 6.1196
0.457 6.1155
0.446 6.1102
0.436 6.1039
0.426 6.0966
0.417 6.0884
0.408 6.0793
0.401 6.0694
0.395 6.0589
0.39 6.0478
0.385 6.0363
0.382 6.0244
0.381 6.0123
0.38 6
0.381 5.9877
0.382 5.9756
0.385 5.9637
0.39 5.9522
0.395 5.9411
0.401 5.9306
0.408 5.9207
0.417 5.9116
0.426 5.9034
0.436 5.8961
0.446 5.8898
0.457 5.8845
0.469 5.8804
0.481 5.8774
0.493 5.8756
0.505 5.875
0.517 5.8756
0.529 5.8774
0.541 5.8804
0.553 5.8845
0.564 5.8898
0.574 5.8961
0.584 5.9034
0.593 5.9116
0.602 5.9207
0.609 5.9306
0.615 5.9411
0.62 5.9522
0.625 5.9637
0.628 5.9756
0.629 5.9877
0.63 6
0.629 6.0123
0.628 6.0244
0.625 6.0363
0.62 6.0478
0.615 6.0589
0.609 6.0694
0.602 6.0793
0.593 6.0884
0.584 6.0966
0.574 6.1039
0.564 6.1102
0.553 6.1155
0.541 6.1196
0.529 6.1226
0.517 6.1244
0.505 6.125
END
VIA POLYGON
0 65 1 N 19 1 1 100 100 0 0 0 Y
TOLEVEL 7 RING NOCOVERS
USER_DAT FromImport
11.049 4.8
11.037 4.7994
11.025 4.7976
11.013 4.7946
11.001 4.7905
10.99 4.7852
10.98 4.7789
10.97 4.7716
10.961 4.7634
10.952 4.7543
10.945 4.7444
10.939 4.7339
10.934 4.7228
10.929 4.7113
10.926 4.6994
10.925 4.6873
10.924 4.675
10.925 4.6627
10.926 4.6506
10.929 4.6387
10.934 4.6272
10.939 4.6161
10.945 4.6056
10.952 4.5957
10.961 4.5866
10.97 4.5784
10.98 4.5711
10.99 4.5648
11.001 4.5595
11.013 4.5554
11.025 4.5524
11.037 4.5506
11.049 4.55
11.061 4.5506
11.073 4.5524
11.085 4.5554
11.097 4.5595
11.108 4.5648
11.118 4.5711
11.128 4.5784
11.137 4.5866
11.146 4.5957
11.153 4.6056
11.159 4.6161
11.164 4.6272
11.169 4.6387
11.172 4.6506
11.173 4.6627
11.174 4.675
11.173 4.6873
11.172 4.6994
11.169 4.7113
11.164 4.7228
11.159 4.7339
11.153 4.7444
11.146 4.7543
11.137 4.7634
11.128 4.7716
11.118 4.7789
11.108 4.7852
11.097 4.7905
11.085 4.7946
11.073 4.7976
11.061 4.7994
11.049 4.8
END
VIA POLYGON
0 65 1 N 20 1 1 100 100 0 0 0 Y
TOLEVEL 7 RING NOCOVERS
USER_DAT FromImport
11.049 5.45
11.037 5.4494
11.025 5.4476
11.013 5.4446
11.001 5.4405
10.99 5.4352
10.98 5.4289
10.97 5.4216
10.961 5.4134
10.952 5.4043
10.945 5.3944
10.939 5.3839
10.934 5.3728
10.929 5.3613
10.926 5.3494
10.925 5.3373
10.924 5.325
10.925 5.3127
10.926 5.3006
10.929 5.2887
10.934 5.2772
10.939 5.2661
10.945 5.2556
10.952 5.2457
10.961 5.2366
10.97 5.2284
10.98 5.2211
10.99 5.2148
11.001 5.2095
11.013 5.2054
11.025 5.2024
11.037 5.2006
11.049 5.2
11.061 5.2006
11.073 5.2024
11.085 5.2054
11.097 5.2095
11.108 5.2148
11.118 5.2211
11.128 5.2284
11.137 5.2366
11.146 5.2457
11.153 5.2556
11.159 5.2661
11.164 5.2772
11.169 5.2887
11.172 5.3006
11.173 5.3127
11.174 5.325
11.173 5.3373
11.172 5.3494
11.169 5.3613
11.164 5.3728
11.159 5.3839
11.153 5.3944
11.146 5.4043
11.137 5.4134
11.128 5.4216
11.118 5.4289
11.108 5.4352
11.097 5.4405
11.085 5.4446
11.073 5.4476
11.061 5.4494
11.049 5.45
END
0 96 0 N 21 1 1 100 100 0 0 0 Y
USER_DAT FromImport
10.832 4.9495
10.836 4.9486
10.841 4.9471
10.846 4.9453
10.85 4.9429
10.854 4.9402
10.858 4.9371
10.89354755 4.901474491
10.908 4.9109
10.932 4.9236
10.957 4.9339
10.982 4.9418
11.009 4.947
11.036 4.9497
11.063 4.9497
11.09 4.947
11.116 4.9418
11.142 4.9339
11.167 4.9236
11.191 4.9109
11.213 4.8959
11.234 4.8788
11.253 4.8597
11.27 4.8388
11.285 4.8164
11.298 4.7926
11.308 4.7676
11.316 4.7418
11.321 4.7154
11.324 4.6885
11.324 4.6615
11.321 4.6346
11.316 4.6082
11.308 4.5824
11.298 4.5574
11.285 4.5336
11.27 4.5112
11.253 4.4903
11.234 4.4712
11.213 4.4541
11.191 4.4391
11.167 4.4264
11.142 4.4161
11.116 4.4082
11.09 4.403
11.063 4.4003
11.036 4.4003
11.009 4.403
10.982 4.4082
10.957 4.4161
10.932 4.4264
10.908 4.4391
10.885 4.4541
10.865 4.4712
10.845 4.4903
10.828 4.5112
10.813 4.5336
10.801 4.5574
10.79 4.5824
10.782 4.6082
10.777 4.6346
10.775 4.6615
10.775 4.6885
10.777 4.7154
10.782 4.7418
10.79 4.7676
10.801 4.7926
10.813 4.8164
10.82265689 4.83082096
10.80343589 4.85
1.42565342 4.85
1.289 4.7129
1.285 4.7098
1.281 4.7071
1.276 4.7047
1.272 4.7029
1.267 4.7014
1.262 4.7005
1.257 4.7
1.005 4.7
1.005 4.675
0.005 4.675
0.005 4.825
1.005 4.825
1.005 4.8
1.23434658 4.8
1.371 4.9371
1.375 4.9402
1.379 4.9429
1.384 4.9453
1.388 4.9471
1.393 4.9486
1.398 4.9495
1.403 4.95
10.827 4.95
10.832 4.9495
END
0 96 0 N 23 1 1 100 100 0 0 0 Y
USER_DAT FromImport
11.09 5.597
11.116 5.5918
11.142 5.5839
11.167 5.5736
11.191 5.5609
11.213 5.5459
11.234 5.5288
11.253 5.5097
11.27 5.4888
11.285 5.4664
11.298 5.4426
11.308 5.4176
11.316 5.3918
11.321 5.3654
11.324 5.3385
11.324 5.3115
11.321 5.2846
11.316 5.2582
11.308 5.2324
11.298 5.2074
11.285 5.1836
11.27 5.1612
11.253 5.1403
11.234 5.1212
11.213 5.1041
11.191 5.0891
11.167 5.0764
11.142 5.0661
11.116 5.0582
11.09 5.053
11.063 5.0503
11.036 5.0503
11.009 5.053
10.982 5.0582
10.957 5.0661
10.932 5.0764
10.908 5.0891
10.89354755 5.098525509
10.858 5.0629
10.854 5.0598
10.85 5.0571
10.846 5.0547
10.841 5.0529
10.836 5.0514
10.832 5.0505
10.827 5.05
1.403 5.05
1.398 5.0505
1.393 5.0514
1.388 5.0529
1.384 5.0547
1.379 5.0571
1.375 5.0598
1.371 5.0629
1.23434658 5.2
1.005 5.2
1.005 5.175
0.005 5.175
0.005 5.325
1.005 5.325
1.005 5.3
1.257 5.3
1.262 5.2995
1.267 5.2986
1.272 5.2971
1.276 5.2953
1.281 5.2929
1.285 5.2902
1.289 5.2871
1.42565342 5.15
10.80343589 5.15
10.82265689 5.16917904
10.813 5.1836
10.801 5.2074
10.79 5.2324
10.782 5.2582
10.777 5.2846
10.775 5.3115
10.775 5.3385
10.777 5.3654
10.782 5.3918
10.79 5.4176
10.801 5.4426
10.813 5.4664
10.828 5.4888
10.845 5.5097
10.865 5.5288
10.885 5.5459
10.908 5.5609
10.932 5.5736
10.957 5.5839
10.982 5.5918
11.009 5.597
11.036 5.5997
11.063 5.5997
11.09 5.597
END
0 61 0 N 25 1 1 100 100 0 0 0 Y
USER_DAT FromImport
0.545 3.522
0.572 3.5168
0.598 3.5089
0.623 3.4986
0.646 3.4859
0.669 3.4709
0.69 3.4538
0.709 3.4347
0.726 3.4138
0.741 3.3914
0.754 3.3676
0.764 3.3426
0.7694573643 3.325
1.005 3.325
1.005 3.175
0.7694573643 3.175
0.764 3.1574
0.754 3.1324
0.741 3.1086
0.726 3.0862
0.709 3.0653
0.69 3.0462
0.669 3.0291
0.646 3.0141
0.623 3.0014
0.598 2.9911
0.572 2.9832
0.545 2.978
0.518 2.9753
0.492 2.9753
0.465 2.978
0.438 2.9832
0.412 2.9911
0.387 3.0014
0.364 3.0141
0.341 3.0291
0.32 3.0462
0.301 3.0653
0.284 3.0862
0.269 3.1086
0.256 3.1324
0.246 3.1574
0.2405426357 3.175
0.005 3.175
0.005 3.325
0.2405426357 3.325
0.246 3.3426
0.256 3.3676
0.269 3.3914
0.284 3.4138
0.301 3.4347
0.32 3.4538
0.341 3.4709
0.364 3.4859
0.387 3.4986
0.412 3.5089
0.438 3.5168
0.465 3.522
0.492 3.5247
0.518 3.5247
0.545 3.522
END
1 100 0 N 28 1 1 100 100 0 0 0 Y
TLAYNAM Metal2 INH
25.025 6.75
11.089 6.75
11.089 6.75
11.089 6.75
11.089 5.725
11.00990526 5.725
10.93251379 5.709682938
10.8590597 5.679240299
10.79429492 5.635524068
10.73951803 5.580985339
10.69346247 5.511987295
10.66393184 5.44031565
10.649 5.365342105
10.649 5.284657895
10.66393184 5.20968435
10.69346247 5.138012705
10.73937223 5.069233092
10.767 5.042
10.77 5.0373
10.774 5.0322
10.777 5.0268
10.779 5.0211
10.781 5.0152
10.782 5.0092
10.783 5.0031
10.783 4.9969
10.782 4.9908
10.781 4.9848
10.779 4.9789
10.777 4.9732
10.774 4.9678
10.77 4.9627
10.767 4.958
10.73937223 4.930766908
10.69346247 4.861987295
10.66393184 4.79031565
10.649 4.715342105
10.649 4.6386
10.649 4.634657895
10.66393184 4.55968435
10.69346247 4.488012705
10.73951803 4.419014661
10.79429492 4.364475932
10.8590597 4.320759701
10.93251379 4.290317062
11.00990526 4.275
11.089 4.275
11.16539378 4.290278756
11.23920264 4.320868429
11.30459629 4.364464194
11.36132723 4.421779128
11.40292467 4.48409826
11.43406816 4.55968435
11.449 4.634657895
11.449 4.715342105
11.43406816 4.79031565
11.40292467 4.86590174
11.36128459 4.928284757
11.33745363 4.952466165
11.336 4.9536
11.332 4.958
11.328 4.9627
11.325 4.9678
11.322 4.9732
11.319 4.9789
11.318 4.9848
11.316 4.9908
11.316 4.9969
11.316 5.0031
11.316 5.0092
11.318 5.0152
11.319 5.0211
11.322 5.0268
11.325 5.0322
11.328 5.0373
11.332 5.042
11.336 5.0464
11.33745363 5.047533835
11.36128459 5.071715243
11.40292467 5.13409826
11.43406816 5.20968435
11.449 5.284657895
11.449 5.365342105
11.43406816 5.44031565
11.40292467 5.51590174
11.36132723 5.578220872
11.30459629 5.635535806
11.23920264 5.679131571
11.16539378 5.709721244
11.089 5.725
11.089 6.75
25.025 6.75
25.025 0.25
0 0.25
0 2.75
0 6.75
1.110223025e-16 6.75
1.110223025e-16 9.25
25.025 9.25
25.025 6.75
END
1 65 0 N 29 1 1 100 100 0 0 0 Y
USER_DAT FromImport
11.036 4.9497
11.009 4.947
10.982 4.9418
10.957 4.9339
10.932 4.9236
10.908 4.9109
10.885 4.8959
10.865 4.8788
10.845 4.8597
10.828 4.8388
10.813 4.8164
10.801 4.7926
10.79 4.7676
10.782 4.7418
10.777 4.7154
10.775 4.6885
10.775 4.6615
10.777 4.6346
10.782 4.6082
10.79 4.5824
10.801 4.5574
10.813 4.5336
10.828 4.5112
10.845 4.4903
10.865 4.4712
10.885 4.4541
10.908 4.4391
10.932 4.4264
10.957 4.4161
10.982 4.4082
11.009 4.403
11.036 4.4003
11.063 4.4003
11.09 4.403
11.116 4.4082
11.142 4.4161
11.167 4.4264
11.191 4.4391
11.213 4.4541
11.234 4.4712
11.253 4.4903
11.27 4.5112
11.285 4.5336
11.298 4.5574
11.308 4.5824
11.316 4.6082
11.321 4.6346
11.324 4.6615
11.324 4.6885
11.321 4.7154
11.316 4.7418
11.308 4.7676
11.298 4.7926
11.285 4.8164
11.27 4.8388
11.253 4.8597
11.234 4.8788
11.213 4.8959
11.191 4.9109
11.167 4.9236
11.142 4.9339
11.116 4.9418
11.09 4.947
11.063 4.9497
11.036 4.9497
END
1 65 0 N 30 1 1 100 100 0 0 0 Y
USER_DAT FromImport
11.036 5.5997
11.009 5.597
10.982 5.5918
10.957 5.5839
10.932 5.5736
10.908 5.5609
10.885 5.5459
10.865 5.5288
10.845 5.5097
10.828 5.4888
10.813 5.4664
10.801 5.4426
10.79 5.4176
10.782 5.3918
10.777 5.3654
10.775 5.3385
10.775 5.3115
10.777 5.2846
10.782 5.2582
10.79 5.2324
10.801 5.2074
10.813 5.1836
10.828 5.1612
10.845 5.1403
10.865 5.1212
10.885 5.1041
10.908 5.0891
10.932 5.0764
10.957 5.0661
10.982 5.0582
11.009 5.053
11.036 5.0503
11.063 5.0503
11.09 5.053
11.116 5.0582
11.142 5.0661
11.167 5.0764
11.191 5.0891
11.213 5.1041
11.234 5.1212
11.253 5.1403
11.27 5.1612
11.285 5.1836
11.298 5.2074
11.308 5.2324
11.316 5.2582
11.321 5.2846
11.324 5.3115
11.324 5.3385
11.321 5.3654
11.316 5.3918
11.308 5.4176
11.298 5.4426
11.285 5.4664
11.27 5.4888
11.253 5.5097
11.234 5.5288
11.213 5.5459
11.191 5.5609
11.167 5.5736
11.142 5.5839
11.116 5.5918
11.09 5.597
11.063 5.5997
11.036 5.5997
END
2 65 0 N 33 1 1 100 100 0 0 0 Y
USER_DAT FromImport
0.492 3.5247
0.465 3.522
0.438 3.5168
0.412 3.5089
0.387 3.4986
0.364 3.4859
0.341 3.4709
0.32 3.4538
0.301 3.4347
0.284 3.4138
0.269 3.3914
0.256 3.3676
0.246 3.3426
0.238 3.3168
0.233 3.2904
0.23 3.2635
0.23 3.2365
0.233 3.2096
0.238 3.1832
0.246 3.1574
0.256 3.1324
0.269 3.1086
0.284 3.0862
0.301 3.0653
0.32 3.0462
0.341 3.0291
0.364 3.0141
0.387 3.0014
0.412 2.9911
0.438 2.9832
0.465 2.978
0.492 2.9753
0.518 2.9753
0.545 2.978
0.572 2.9832
0.598 2.9911
0.623 3.0014
0.646 3.0141
0.669 3.0291
0.69 3.0462
0.709 3.0653
0.726 3.0862
0.741 3.1086
0.754 3.1324
0.764 3.1574
0.772 3.1832
0.777 3.2096
0.78 3.2365
0.78 3.2635
0.777 3.2904
0.772 3.3168
0.764 3.3426
0.754 3.3676
0.741 3.3914
0.726 3.4138
0.709 3.4347
0.69 3.4538
0.669 3.4709
0.646 3.4859
0.623 3.4986
0.598 3.5089
0.572 3.5168
0.545 3.522
0.518 3.5247
0.492 3.5247
END
2 65 0 N 34 1 1 100 100 0 0 0 Y
USER_DAT FromImport
0.492 6.2747
0.465 6.272
0.438 6.2668
0.412 6.2589
0.387 6.2486
0.364 6.2359
0.341 6.2209
0.32 6.2038
0.301 6.1847
0.284 6.1638
0.269 6.1414
0.256 6.1176
0.246 6.0926
0.238 6.0668
0.233 6.0404
0.23 6.0135
0.23 5.9865
0.233 5.9596
0.238 5.9332
0.246 5.9074
0.256 5.8824
0.269 5.8586
0.284 5.8362
0.301 5.8153
0.32 5.7962
0.341 5.7791
0.364 5.7641
0.387 5.7514
0.412 5.7411
0.438 5.7332
0.465 5.728
0.492 5.7253
0.518 5.7253
0.545 5.728
0.572 5.7332
0.598 5.7411
0.623 5.7514
0.646 5.7641
0.669 5.7791
0.69 5.7962
0.709 5.8153
0.726 5.8362
0.741 5.8586
0.754 5.8824
0.764 5.9074
0.772 5.9332
0.777 5.9596
0.78 5.9865
0.78 6.0135
0.777 6.0404
0.772 6.0668
0.764 6.0926
0.754 6.1176
0.741 6.1414
0.726 6.1638
0.709 6.1847
0.69 6.2038
0.669 6.2209
0.646 6.2359
0.623 6.2486
0.598 6.2589
0.572 6.2668
0.545 6.272
0.518 6.2747
0.492 6.2747
END
2 65 0 N 35 1 1 100 100 0 0 0 Y
USER_DAT FromImport
10.992 4.0247
10.965 4.022
10.938 4.0168
10.912 4.0089
10.887 3.9986
10.864 3.9859
10.841 3.9709
10.82 3.9538
10.801 3.9347
10.784 3.9138
10.769 3.8914
10.756 3.8676
10.746 3.8426
10.738 3.8168
10.733 3.7904
10.73 3.7635
10.73 3.7365
10.733 3.7096
10.738 3.6832
10.746 3.6574
10.756 3.6324
10.769 3.6086
10.784 3.5862
10.801 3.5653
10.82 3.5462
10.841 3.5291
10.864 3.5141
10.887 3.5014
10.912 3.4911
10.938 3.4832
10.965 3.478
10.992 3.4753
11.018 3.4753
11.045 3.478
11.072 3.4832
11.098 3.4911
11.123 3.5014
11.146 3.5141
11.169 3.5291
11.19 3.5462
11.209 3.5653
11.226 3.5862
11.241 3.6086
11.254 3.6324
11.264 3.6574
11.272 3.6832
11.277 3.7096
11.28 3.7365
11.28 3.7635
11.277 3.7904
11.272 3.8168
11.264 3.8426
11.254 3.8676
11.241 3.8914
11.226 3.9138
11.209 3.9347
11.19 3.9538
11.169 3.9709
11.146 3.9859
11.123 3.9986
11.098 4.0089
11.072 4.0168
11.045 4.022
11.018 4.0247
10.992 4.0247
END
2 65 0 N 36 1 1 100 100 0 0 0 Y
USER_DAT FromImport
10.992 6.5247
10.965 6.522
10.938 6.5168
10.912 6.5089
10.887 6.4986
10.864 6.4859
10.841 6.4709
10.82 6.4538
10.801 6.4347
10.784 6.4138
10.769 6.3914
10.756 6.3676
10.746 6.3426
10.738 6.3168
10.733 6.2904
10.73 6.2635
10.73 6.2365
10.733 6.2096
10.738 6.1832
10.746 6.1574
10.756 6.1324
10.769 6.1086
10.784 6.0862
10.801 6.0653
10.82 6.0462
10.841 6.0291
10.864 6.0141
10.887 6.0014
10.912 5.9911
10.938 5.9832
10.965 5.978
10.992 5.9753
11.018 5.9753
11.045 5.978
11.072 5.9832
11.098 5.9911
11.123 6.0014
11.146 6.0141
11.169 6.0291
11.19 6.0462
11.209 6.0653
11.226 6.0862
11.241 6.1086
11.254 6.1324
11.264 6.1574
11.272 6.1832
11.277 6.2096
11.28 6.2365
11.28 6.2635
11.277 6.2904
11.272 6.3168
11.264 6.3426
11.254 6.3676
11.241 6.3914
11.226 6.4138
11.209 6.4347
11.19 6.4538
11.169 6.4709
11.146 6.4859
11.123 6.4986
11.098 6.5089
11.072 6.5168
11.045 6.522
11.018 6.5247
10.992 6.5247
END
2 65 0 N 37 1 1 100 100 0 0 0 Y
USER_DAT FromImport
11.036 4.9497
11.009 4.947
10.982 4.9418
10.957 4.9339
10.932 4.9236
10.908 4.9109
10.885 4.8959
10.865 4.8788
10.845 4.8597
10.828 4.8388
10.813 4.8164
10.801 4.7926
10.79 4.7676
10.782 4.7418
10.777 4.7154
10.775 4.6885
10.775 4.6615
10.777 4.6346
10.782 4.6082
10.79 4.5824
10.801 4.5574
10.813 4.5336
10.828 4.5112
10.845 4.4903
10.865 4.4712
10.885 4.4541
10.908 4.4391
10.932 4.4264
10.957 4.4161
10.982 4.4082
11.009 4.403
11.036 4.4003
11.063 4.4003
11.09 4.403
11.116 4.4082
11.142 4.4161
11.167 4.4264
11.191 4.4391
11.213 4.4541
11.234 4.4712
11.253 4.4903
11.27 4.5112
11.285 4.5336
11.298 4.5574
11.308 4.5824
11.316 4.6082
11.321 4.6346
11.324 4.6615
11.324 4.6885
11.321 4.7154
11.316 4.7418
11.308 4.7676
11.298 4.7926
11.285 4.8164
11.27 4.8388
11.253 4.8597
11.234 4.8788
11.213 4.8959
11.191 4.9109
11.167 4.9236
11.142 4.9339
11.116 4.9418
11.09 4.947
11.063 4.9497
11.036 4.9497
END
2 65 0 N 38 1 1 100 100 0 0 0 Y
USER_DAT FromImport
11.036 5.5997
11.009 5.597
10.982 5.5918
10.957 5.5839
10.932 5.5736
10.908 5.5609
10.885 5.5459
10.865 5.5288
10.845 5.5097
10.828 5.4888
10.813 5.4664
10.801 5.4426
10.79 5.4176
10.782 5.3918
10.777 5.3654
10.775 5.3385
10.775 5.3115
10.777 5.2846
10.782 5.2582
10.79 5.2324
10.801 5.2074
10.813 5.1836
10.828 5.1612
10.845 5.1403
10.865 5.1212
10.885 5.1041
10.908 5.0891
10.932 5.0764
10.957 5.0661
10.982 5.0582
11.009 5.053
11.036 5.0503
11.063 5.0503
11.09 5.053
11.116 5.0582
11.142 5.0661
11.167 5.0764
11.191 5.0891
11.213 5.1041
11.234 5.1212
11.253 5.1403
11.27 5.1612
11.285 5.1836
11.298 5.2074
11.308 5.2324
11.316 5.2582
11.321 5.2846
11.324 5.3115
11.324 5.3385
11.321 5.3654
11.316 5.3918
11.308 5.4176
11.298 5.4426
11.285 5.4664
11.27 5.4888
11.253 5.5097
11.234 5.5288
11.213 5.5459
11.191 5.5609
11.167 5.5736
11.142 5.5839
11.116 5.5918
11.09 5.597
11.063 5.5997
11.036 5.5997
END
3 65 0 N 41 1 1 100 100 0 0 0 Y
USER_DAT FromImport
0.492 3.5247
0.465 3.522
0.438 3.5168
0.412 3.5089
0.387 3.4986
0.364 3.4859
0.341 3.4709
0.32 3.4538
0.301 3.4347
0.284 3.4138
0.269 3.3914
0.256 3.3676
0.246 3.3426
0.238 3.3168
0.233 3.2904
0.23 3.2635
0.23 3.2365
0.233 3.2096
0.238 3.1832
0.246 3.1574
0.256 3.1324
0.269 3.1086
0.284 3.0862
0.301 3.0653
0.32 3.0462
0.341 3.0291
0.364 3.0141
0.387 3.0014
0.412 2.9911
0.438 2.9832
0.465 2.978
0.492 2.9753
0.518 2.9753
0.545 2.978
0.572 2.9832
0.598 2.9911
0.623 3.0014
0.646 3.0141
0.669 3.0291
0.69 3.0462
0.709 3.0653
0.726 3.0862
0.741 3.1086
0.754 3.1324
0.764 3.1574
0.772 3.1832
0.777 3.2096
0.78 3.2365
0.78 3.2635
0.777 3.2904
0.772 3.3168
0.764 3.3426
0.754 3.3676
0.741 3.3914
0.726 3.4138
0.709 3.4347
0.69 3.4538
0.669 3.4709
0.646 3.4859
0.623 3.4986
0.598 3.5089
0.572 3.5168
0.545 3.522
0.518 3.5247
0.492 3.5247
END
3 65 0 N 42 1 1 100 100 0 0 0 Y
USER_DAT FromImport
0.492 6.2747
0.465 6.272
0.438 6.2668
0.412 6.2589
0.387 6.2486
0.364 6.2359
0.341 6.2209
0.32 6.2038
0.301 6.1847
0.284 6.1638
0.269 6.1414
0.256 6.1176
0.246 6.0926
0.238 6.0668
0.233 6.0404
0.23 6.0135
0.23 5.9865
0.233 5.9596
0.238 5.9332
0.246 5.9074
0.256 5.8824
0.269 5.8586
0.284 5.8362
0.301 5.8153
0.32 5.7962
0.341 5.7791
0.364 5.7641
0.387 5.7514
0.412 5.7411
0.438 5.7332
0.465 5.728
0.492 5.7253
0.518 5.7253
0.545 5.728
0.572 5.7332
0.598 5.7411
0.623 5.7514
0.646 5.7641
0.669 5.7791
0.69 5.7962
0.709 5.8153
0.726 5.8362
0.741 5.8586
0.754 5.8824
0.764 5.9074
0.772 5.9332
0.777 5.9596
0.78 5.9865
0.78 6.0135
0.777 6.0404
0.772 6.0668
0.764 6.0926
0.754 6.1176
0.741 6.1414
0.726 6.1638
0.709 6.1847
0.69 6.2038
0.669 6.2209
0.646 6.2359
0.623 6.2486
0.598 6.2589
0.572 6.2668
0.545 6.272
0.518 6.2747
0.492 6.2747
END
3 65 0 N 43 1 1 100 100 0 0 0 Y
USER_DAT FromImport
10.992 4.0247
10.965 4.022
10.938 4.0168
10.912 4.0089
10.887 3.9986
10.864 3.9859
10.841 3.9709
10.82 3.9538
10.801 3.9347
10.784 3.9138
10.769 3.8914
10.756 3.8676
10.746 3.8426
10.738 3.8168
10.733 3.7904
10.73 3.7635
10.73 3.7365
10.733 3.7096
10.738 3.6832
10.746 3.6574
10.756 3.6324
10.769 3.6086
10.784 3.5862
10.801 3.5653
10.82 3.5462
10.841 3.5291
10.864 3.5141
10.887 3.5014
10.912 3.4911
10.938 3.4832
10.965 3.478
10.992 3.4753
11.018 3.4753
11.045 3.478
11.072 3.4832
11.098 3.4911
11.123 3.5014
11.146 3.5141
11.169 3.5291
11.19 3.5462
11.209 3.5653
11.226 3.5862
11.241 3.6086
11.254 3.6324
11.264 3.6574
11.272 3.6832
11.277 3.7096
11.28 3.7365
11.28 3.7635
11.277 3.7904
11.272 3.8168
11.264 3.8426
11.254 3.8676
11.241 3.8914
11.226 3.9138
11.209 3.9347
11.19 3.9538
11.169 3.9709
11.146 3.9859
11.123 3.9986
11.098 4.0089
11.072 4.0168
11.045 4.022
11.018 4.0247
10.992 4.0247
END
3 65 0 N 44 1 1 100 100 0 0 0 Y
USER_DAT FromImport
10.992 6.5247
10.965 6.522
10.938 6.5168
10.912 6.5089
10.887 6.4986
10.864 6.4859
10.841 6.4709
10.82 6.4538
10.801 6.4347
10.784 6.4138
10.769 6.3914
10.756 6.3676
10.746 6.3426
10.738 6.3168
10.733 6.2904
10.73 6.2635
10.73 6.2365
10.733 6.2096
10.738 6.1832
10.746 6.1574
10.756 6.1324
10.769 6.1086
10.784 6.0862
10.801 6.0653
10.82 6.0462
10.841 6.0291
10.864 6.0141
10.887 6.0014
10.912 5.9911
10.938 5.9832
10.965 5.978
10.992 5.9753
11.018 5.9753
11.045 5.978
11.072 5.9832
11.098 5.9911
11.123 6.0014
11.146 6.0141
11.169 6.0291
11.19 6.0462
11.209 6.0653
11.226 6.0862
11.241 6.1086
11.254 6.1324
11.264 6.1574
11.272 6.1832
11.277 6.2096
11.28 6.2365
11.28 6.2635
11.277 6.2904
11.272 6.3168
11.264 6.3426
11.254 6.3676
11.241 6.3914
11.226 6.4138
11.209 6.4347
11.19 6.4538
11.169 6.4709
11.146 6.4859
11.123 6.4986
11.098 6.5089
11.072 6.5168
11.045 6.522
11.018 6.5247
10.992 6.5247
END
3 65 0 N 45 1 1 100 100 0 0 0 Y
USER_DAT FromImport
11.036 4.9497
11.009 4.947
10.982 4.9418
10.957 4.9339
10.932 4.9236
10.908 4.9109
10.885 4.8959
10.865 4.8788
10.845 4.8597
10.828 4.8388
10.813 4.8164
10.801 4.7926
10.79 4.7676
10.782 4.7418
10.777 4.7154
10.775 4.6885
10.775 4.6615
10.777 4.6346
10.782 4.6082
10.79 4.5824
10.801 4.5574
10.813 4.5336
10.828 4.5112
10.845 4.4903
10.865 4.4712
10.885 4.4541
10.908 4.4391
10.932 4.4264
10.957 4.4161
10.982 4.4082
11.009 4.403
11.036 4.4003
11.063 4.4003
11.09 4.403
11.116 4.4082
11.142 4.4161
11.167 4.4264
11.191 4.4391
11.213 4.4541
11.234 4.4712
11.253 4.4903
11.27 4.5112
11.285 4.5336
11.298 4.5574
11.308 4.5824
11.316 4.6082
11.321 4.6346
11.324 4.6615
11.324 4.6885
11.321 4.7154
11.316 4.7418
11.308 4.7676
11.298 4.7926
11.285 4.8164
11.27 4.8388
11.253 4.8597
11.234 4.8788
11.213 4.8959
11.191 4.9109
11.167 4.9236
11.142 4.9339
11.116 4.9418
11.09 4.947
11.063 4.9497
11.036 4.9497
END
3 65 0 N 46 1 1 100 100 0 0 0 Y
USER_DAT FromImport
11.036 5.5997
11.009 5.597
10.982 5.5918
10.957 5.5839
10.932 5.5736
10.908 5.5609
10.885 5.5459
10.865 5.5288
10.845 5.5097
10.828 5.4888
10.813 5.4664
10.801 5.4426
10.79 5.4176
10.782 5.3918
10.777 5.3654
10.775 5.3385
10.775 5.3115
10.777 5.2846
10.782 5.2582
10.79 5.2324
10.801 5.2074
10.813 5.1836
10.828 5.1612
10.845 5.1403
10.865 5.1212
10.885 5.1041
10.908 5.0891
10.932 5.0764
10.957 5.0661
10.982 5.0582
11.009 5.053
11.036 5.0503
11.063 5.0503
11.09 5.053
11.116 5.0582
11.142 5.0661
11.167 5.0764
11.191 5.0891
11.213 5.1041
11.234 5.1212
11.253 5.1403
11.27 5.1612
11.285 5.1836
11.298 5.2074
11.308 5.2324
11.316 5.2582
11.321 5.2846
11.324 5.3115
11.324 5.3385
11.321 5.3654
11.316 5.3918
11.308 5.4176
11.298 5.4426
11.285 5.4664
11.27 5.4888
11.253 5.5097
11.234 5.5288
11.213 5.5459
11.191 5.5609
11.167 5.5736
11.142 5.5839
11.116 5.5918
11.09 5.597
11.063 5.5997
11.036 5.5997
END
4 65 0 N 49 1 1 100 100 0 0 0 Y
USER_DAT FromImport
0.492 3.5247
0.465 3.522
0.438 3.5168
0.412 3.5089
0.387 3.4986
0.364 3.4859
0.341 3.4709
0.32 3.4538
0.301 3.4347
0.284 3.4138
0.269 3.3914
0.256 3.3676
0.246 3.3426
0.238 3.3168
0.233 3.2904
0.23 3.2635
0.23 3.2365
0.233 3.2096
0.238 3.1832
0.246 3.1574
0.256 3.1324
0.269 3.1086
0.284 3.0862
0.301 3.0653
0.32 3.0462
0.341 3.0291
0.364 3.0141
0.387 3.0014
0.412 2.9911
0.438 2.9832
0.465 2.978
0.492 2.9753
0.518 2.9753
0.545 2.978
0.572 2.9832
0.598 2.9911
0.623 3.0014
0.646 3.0141
0.669 3.0291
0.69 3.0462
0.709 3.0653
0.726 3.0862
0.741 3.1086
0.754 3.1324
0.764 3.1574
0.772 3.1832
0.777 3.2096
0.78 3.2365
0.78 3.2635
0.777 3.2904
0.772 3.3168
0.764 3.3426
0.754 3.3676
0.741 3.3914
0.726 3.4138
0.709 3.4347
0.69 3.4538
0.669 3.4709
0.646 3.4859
0.623 3.4986
0.598 3.5089
0.572 3.5168
0.545 3.522
0.518 3.5247
0.492 3.5247
END
4 65 0 N 50 1 1 100 100 0 0 0 Y
USER_DAT FromImport
0.492 6.2747
0.465 6.272
0.438 6.2668
0.412 6.2589
0.387 6.2486
0.364 6.2359
0.341 6.2209
0.32 6.2038
0.301 6.1847
0.284 6.1638
0.269 6.1414
0.256 6.1176
0.246 6.0926
0.238 6.0668
0.233 6.0404
0.23 6.0135
0.23 5.9865
0.233 5.9596
0.238 5.9332
0.246 5.9074
0.256 5.8824
0.269 5.8586
0.284 5.8362
0.301 5.8153
0.32 5.7962
0.341 5.7791
0.364 5.7641
0.387 5.7514
0.412 5.7411
0.438 5.7332
0.465 5.728
0.492 5.7253
0.518 5.7253
0.545 5.728
0.572 5.7332
0.598 5.7411
0.623 5.7514
0.646 5.7641
0.669 5.7791
0.69 5.7962
0.709 5.8153
0.726 5.8362
0.741 5.8586
0.754 5.8824
0.764 5.9074
0.772 5.9332
0.777 5.9596
0.78 5.9865
0.78 6.0135
0.777 6.0404
0.772 6.0668
0.764 6.0926
0.754 6.1176
0.741 6.1414
0.726 6.1638
0.709 6.1847
0.69 6.2038
0.669 6.2209
0.646 6.2359
0.623 6.2486
0.598 6.2589
0.572 6.2668
0.545 6.272
0.518 6.2747
0.492 6.2747
END
4 65 0 N 51 1 1 100 100 0 0 0 Y
USER_DAT FromImport
10.992 4.0247
10.965 4.022
10.938 4.0168
10.912 4.0089
10.887 3.9986
10.864 3.9859
10.841 3.9709
10.82 3.9538
10.801 3.9347
10.784 3.9138
10.769 3.8914
10.756 3.8676
10.746 3.8426
10.738 3.8168
10.733 3.7904
10.73 3.7635
10.73 3.7365
10.733 3.7096
10.738 3.6832
10.746 3.6574
10.756 3.6324
10.769 3.6086
10.784 3.5862
10.801 3.5653
10.82 3.5462
10.841 3.5291
10.864 3.5141
10.887 3.5014
10.912 3.4911
10.938 3.4832
10.965 3.478
10.992 3.4753
11.018 3.4753
11.045 3.478
11.072 3.4832
11.098 3.4911
11.123 3.5014
11.146 3.5141
11.169 3.5291
11.19 3.5462
11.209 3.5653
11.226 3.5862
11.241 3.6086
11.254 3.6324
11.264 3.6574
11.272 3.6832
11.277 3.7096
11.28 3.7365
11.28 3.7635
11.277 3.7904
11.272 3.8168
11.264 3.8426
11.254 3.8676
11.241 3.8914
11.226 3.9138
11.209 3.9347
11.19 3.9538
11.169 3.9709
11.146 3.9859
11.123 3.9986
11.098 4.0089
11.072 4.0168
11.045 4.022
11.018 4.0247
10.992 4.0247
END
4 65 0 N 52 1 1 100 100 0 0 0 Y
USER_DAT FromImport
10.992 6.5247
10.965 6.522
10.938 6.5168
10.912 6.5089
10.887 6.4986
10.864 6.4859
10.841 6.4709
10.82 6.4538
10.801 6.4347
10.784 6.4138
10.769 6.3914
10.756 6.3676
10.746 6.3426
10.738 6.3168
10.733 6.2904
10.73 6.2635
10.73 6.2365
10.733 6.2096
10.738 6.1832
10.746 6.1574
10.756 6.1324
10.769 6.1086
10.784 6.0862
10.801 6.0653
10.82 6.0462
10.841 6.0291
10.864 6.0141
10.887 6.0014
10.912 5.9911
10.938 5.9832
10.965 5.978
10.992 5.9753
11.018 5.9753
11.045 5.978
11.072 5.9832
11.098 5.9911
11.123 6.0014
11.146 6.0141
11.169 6.0291
11.19 6.0462
11.209 6.0653
11.226 6.0862
11.241 6.1086
11.254 6.1324
11.264 6.1574
11.272 6.1832
11.277 6.2096
11.28 6.2365
11.28 6.2635
11.277 6.2904
11.272 6.3168
11.264 6.3426
11.254 6.3676
11.241 6.3914
11.226 6.4138
11.209 6.4347
11.19 6.4538
11.169 6.4709
11.146 6.4859
11.123 6.4986
11.098 6.5089
11.072 6.5168
11.045 6.522
11.018 6.5247
10.992 6.5247
END
4 65 0 N 53 1 1 100 100 0 0 0 Y
USER_DAT FromImport
11.036 4.9497
11.009 4.947
10.982 4.9418
10.957 4.9339
10.932 4.9236
10.908 4.9109
10.885 4.8959
10.865 4.8788
10.845 4.8597
10.828 4.8388
10.813 4.8164
10.801 4.7926
10.79 4.7676
10.782 4.7418
10.777 4.7154
10.775 4.6885
10.775 4.6615
10.777 4.6346
10.782 4.6082
10.79 4.5824
10.801 4.5574
10.813 4.5336
10.828 4.5112
10.845 4.4903
10.865 4.4712
10.885 4.4541
10.908 4.4391
10.932 4.4264
10.957 4.4161
10.982 4.4082
11.009 4.403
11.036 4.4003
11.063 4.4003
11.09 4.403
11.116 4.4082
11.142 4.4161
11.167 4.4264
11.191 4.4391
11.213 4.4541
11.234 4.4712
11.253 4.4903
11.27 4.5112
11.285 4.5336
11.298 4.5574
11.308 4.5824
11.316 4.6082
11.321 4.6346
11.324 4.6615
11.324 4.6885
11.321 4.7154
11.316 4.7418
11.308 4.7676
11.298 4.7926
11.285 4.8164
11.27 4.8388
11.253 4.8597
11.234 4.8788
11.213 4.8959
11.191 4.9109
11.167 4.9236
11.142 4.9339
11.116 4.9418
11.09 4.947
11.063 4.9497
11.036 4.9497
END
4 65 0 N 54 1 1 100 100 0 0 0 Y
USER_DAT FromImport
11.036 5.5997
11.009 5.597
10.982 5.5918
10.957 5.5839
10.932 5.5736
10.908 5.5609
10.885 5.5459
10.865 5.5288
10.845 5.5097
10.828 5.4888
10.813 5.4664
10.801 5.4426
10.79 5.4176
10.782 5.3918
10.777 5.3654
10.775 5.3385
10.775 5.3115
10.777 5.2846
10.782 5.2582
10.79 5.2324
10.801 5.2074
10.813 5.1836
10.828 5.1612
10.845 5.1403
10.865 5.1212
10.885 5.1041
10.908 5.0891
10.932 5.0764
10.957 5.0661
10.982 5.0582
11.009 5.053
11.036 5.0503
11.063 5.0503
11.09 5.053
11.116 5.0582
11.142 5.0661
11.167 5.0764
11.191 5.0891
11.213 5.1041
11.234 5.1212
11.253 5.1403
11.27 5.1612
11.285 5.1836
11.298 5.2074
11.308 5.2324
11.316 5.2582
11.321 5.2846
11.324 5.3115
11.324 5.3385
11.321 5.3654
11.316 5.3918
11.308 5.4176
11.298 5.4426
11.285 5.4664
11.27 5.4888
11.253 5.5097
11.234 5.5288
11.213 5.5459
11.191 5.5609
11.167 5.5736
11.142 5.5839
11.116 5.5918
11.09 5.597
11.063 5.5997
11.036 5.5997
END
5 65 0 N 57 1 1 100 100 0 0 0 Y
USER_DAT FromImport
0.492 3.5247
0.465 3.522
0.438 3.5168
0.412 3.5089
0.387 3.4986
0.364 3.4859
0.341 3.4709
0.32 3.4538
0.301 3.4347
0.284 3.4138
0.269 3.3914
0.256 3.3676
0.246 3.3426
0.238 3.3168
0.233 3.2904
0.23 3.2635
0.23 3.2365
0.233 3.2096
0.238 3.1832
0.246 3.1574
0.256 3.1324
0.269 3.1086
0.284 3.0862
0.301 3.0653
0.32 3.0462
0.341 3.0291
0.364 3.0141
0.387 3.0014
0.412 2.9911
0.438 2.9832
0.465 2.978
0.492 2.9753
0.518 2.9753
0.545 2.978
0.572 2.9832
0.598 2.9911
0.623 3.0014
0.646 3.0141
0.669 3.0291
0.69 3.0462
0.709 3.0653
0.726 3.0862
0.741 3.1086
0.754 3.1324
0.764 3.1574
0.772 3.1832
0.777 3.2096
0.78 3.2365
0.78 3.2635
0.777 3.2904
0.772 3.3168
0.764 3.3426
0.754 3.3676
0.741 3.3914
0.726 3.4138
0.709 3.4347
0.69 3.4538
0.669 3.4709
0.646 3.4859
0.623 3.4986
0.598 3.5089
0.572 3.5168
0.545 3.522
0.518 3.5247
0.492 3.5247
END
5 65 0 N 58 1 1 100 100 0 0 0 Y
USER_DAT FromImport
0.492 6.2747
0.465 6.272
0.438 6.2668
0.412 6.2589
0.387 6.2486
0.364 6.2359
0.341 6.2209
0.32 6.2038
0.301 6.1847
0.284 6.1638
0.269 6.1414
0.256 6.1176
0.246 6.0926
0.238 6.0668
0.233 6.0404
0.23 6.0135
0.23 5.9865
0.233 5.9596
0.238 5.9332
0.246 5.9074
0.256 5.8824
0.269 5.8586
0.284 5.8362
0.301 5.8153
0.32 5.7962
0.341 5.7791
0.364 5.7641
0.387 5.7514
0.412 5.7411
0.438 5.7332
0.465 5.728
0.492 5.7253
0.518 5.7253
0.545 5.728
0.572 5.7332
0.598 5.7411
0.623 5.7514
0.646 5.7641
0.669 5.7791
0.69 5.7962
0.709 5.8153
0.726 5.8362
0.741 5.8586
0.754 5.8824
0.764 5.9074
0.772 5.9332
0.777 5.9596
0.78 5.9865
0.78 6.0135
0.777 6.0404
0.772 6.0668
0.764 6.0926
0.754 6.1176
0.741 6.1414
0.726 6.1638
0.709 6.1847
0.69 6.2038
0.669 6.2209
0.646 6.2359
0.623 6.2486
0.598 6.2589
0.572 6.2668
0.545 6.272
0.518 6.2747
0.492 6.2747
END
5 65 0 N 59 1 1 100 100 0 0 0 Y
USER_DAT FromImport
10.992 4.0247
10.965 4.022
10.938 4.0168
10.912 4.0089
10.887 3.9986
10.864 3.9859
10.841 3.9709
10.82 3.9538
10.801 3.9347
10.784 3.9138
10.769 3.8914
10.756 3.8676
10.746 3.8426
10.738 3.8168
10.733 3.7904
10.73 3.7635
10.73 3.7365
10.733 3.7096
10.738 3.6832
10.746 3.6574
10.756 3.6324
10.769 3.6086
10.784 3.5862
10.801 3.5653
10.82 3.5462
10.841 3.5291
10.864 3.5141
10.887 3.5014
10.912 3.4911
10.938 3.4832
10.965 3.478
10.992 3.4753
11.018 3.4753
11.045 3.478
11.072 3.4832
11.098 3.4911
11.123 3.5014
11.146 3.5141
11.169 3.5291
11.19 3.5462
11.209 3.5653
11.226 3.5862
11.241 3.6086
11.254 3.6324
11.264 3.6574
11.272 3.6832
11.277 3.7096
11.28 3.7365
11.28 3.7635
11.277 3.7904
11.272 3.8168
11.264 3.8426
11.254 3.8676
11.241 3.8914
11.226 3.9138
11.209 3.9347
11.19 3.9538
11.169 3.9709
11.146 3.9859
11.123 3.9986
11.098 4.0089
11.072 4.0168
11.045 4.022
11.018 4.0247
10.992 4.0247
END
5 65 0 N 60 1 1 100 100 0 0 0 Y
USER_DAT FromImport
10.992 6.5247
10.965 6.522
10.938 6.5168
10.912 6.5089
10.887 6.4986
10.864 6.4859
10.841 6.4709
10.82 6.4538
10.801 6.4347
10.784 6.4138
10.769 6.3914
10.756 6.3676
10.746 6.3426
10.738 6.3168
10.733 6.2904
10.73 6.2635
10.73 6.2365
10.733 6.2096
10.738 6.1832
10.746 6.1574
10.756 6.1324
10.769 6.1086
10.784 6.0862
10.801 6.0653
10.82 6.0462
10.841 6.0291
10.864 6.0141
10.887 6.0014
10.912 5.9911
10.938 5.9832
10.965 5.978
10.992 5.9753
11.018 5.9753
11.045 5.978
11.072 5.9832
11.098 5.9911
11.123 6.0014
11.146 6.0141
11.169 6.0291
11.19 6.0462
11.209 6.0653
11.226 6.0862
11.241 6.1086
11.254 6.1324
11.264 6.1574
11.272 6.1832
11.277 6.2096
11.28 6.2365
11.28 6.2635
11.277 6.2904
11.272 6.3168
11.264 6.3426
11.254 6.3676
11.241 6.3914
11.226 6.4138
11.209 6.4347
11.19 6.4538
11.169 6.4709
11.146 6.4859
11.123 6.4986
11.098 6.5089
11.072 6.5168
11.045 6.522
11.018 6.5247
10.992 6.5247
END
5 71 0 N 61 1 1 100 100 0 0 0 Y
USER_DAT FromImport
11.09 5.597
11.116 5.5918
11.142 5.5839
11.167 5.5736
11.191 5.5609
11.213 5.5459
11.234 5.5288
11.253 5.5097
11.27 5.4888
11.285 5.4664
11.298 5.4426
11.308 5.4176
11.316 5.3918
11.321 5.3654
11.324 5.3385
11.324 5.3115
11.321 5.2846
11.316 5.2582
11.308 5.2324
11.298 5.2074
11.285 5.1836
11.28258929 5.18
27.7 5.18
27.7 5.1
11.232 5.1
11.228 5.1004
11.224 5.1012
11.221 5.1023
11.217 5.1038
11.21448485 5.105309091
11.213 5.1041
11.191 5.0891
11.167 5.0764
11.142 5.0661
11.116 5.0582
11.09 5.053
11.063 5.0503
11.036 5.0503
11.009 5.053
10.982 5.0582
10.957 5.0661
10.932 5.0764
10.908 5.0891
10.885 5.1041
10.865 5.1212
10.845 5.1403
10.828 5.1612
10.813 5.1836
10.801 5.2074
10.79 5.2324
10.782 5.2582
10.777 5.2846
10.775 5.3115
10.775 5.3385
10.777 5.3654
10.782 5.3918
10.79 5.4176
10.801 5.4426
10.813 5.4664
10.828 5.4888
10.845 5.5097
10.865 5.5288
10.885 5.5459
10.908 5.5609
10.932 5.5736
10.957 5.5839
10.982 5.5918
11.009 5.597
11.036 5.5997
11.063 5.5997
11.09 5.597
END
5 71 0 N 63 1 1 100 100 0 0 0 Y
USER_DAT FromImport
11.09 4.947
11.116 4.9418
11.142 4.9339
11.167 4.9236
11.191 4.9109
11.213 4.8959
11.21448485 4.894690909
11.217 4.8962
11.221 4.8977
11.224 4.8988
11.228 4.8996
11.232 4.9
27.7 4.9
27.7 4.82
11.28258929 4.82
11.285 4.8164
11.298 4.7926
11.308 4.7676
11.316 4.7418
11.321 4.7154
11.324 4.6885
11.324 4.6615
11.321 4.6346
11.316 4.6082
11.308 4.5824
11.298 4.5574
11.285 4.5336
11.27 4.5112
11.253 4.4903
11.234 4.4712
11.213 4.4541
11.191 4.4391
11.167 4.4264
11.142 4.4161
11.116 4.4082
11.09 4.403
11.063 4.4003
11.036 4.4003
11.009 4.403
10.982 4.4082
10.957 4.4161
10.932 4.4264
10.908 4.4391
10.885 4.4541
10.865 4.4712
10.845 4.4903
10.828 4.5112
10.813 4.5336
10.801 4.5574
10.79 4.5824
10.782 4.6082
10.777 4.6346
10.775 4.6615
10.775 4.6885
10.777 4.7154
10.782 4.7418
10.79 4.7676
10.801 4.7926
10.813 4.8164
10.828 4.8388
10.845 4.8597
10.865 4.8788
10.885 4.8959
10.908 4.9109
10.932 4.9236
10.957 4.9339
10.982 4.9418
11.009 4.947
11.036 4.9497
11.063 4.9497
11.09 4.947
END
6 96 0 N 67 1 1 100 100 0 0 0 Y
TLAYNAM Metal7 INH
USER_DAT FromImport
27.7 6.75
27.7 2.75
27.7 0.25
0.225 0.25
0.225 2.75
0.225 6.75
0.225 9.25
11.089 9.25
11.089 5.725
11.00990526 5.725
10.93251379 5.709682938
10.8590597 5.679240299
10.79429492 5.635524068
10.73951803 5.580985339
10.69346247 5.511987295
10.66393184 5.44031565
10.649 5.365342105
10.649 5.284657895
10.66393184 5.20968435
10.69346247 5.138012705
10.73937223 5.069233092
10.767 5.042
10.77 5.0373
10.774 5.0322
10.777 5.0268
10.779 5.0211
10.781 5.0152
10.782 5.0092
10.783 5.0031
10.783 4.9969
10.782 4.9908
10.781 4.9848
10.779 4.9789
10.777 4.9732
10.774 4.9678
10.77 4.9627
10.767 4.958
10.73937223 4.930766908
10.69346247 4.861987295
10.66393184 4.79031565
10.649 4.715342105
10.649 4.634657895
10.66393184 4.55968435
10.69346247 4.488012705
10.73951803 4.419014661
10.79429492 4.364475932
10.8590597 4.320759701
10.93251379 4.290317062
11.00990526 4.275
11.089 4.275
11.16539378 4.290278756
11.23920264 4.320868429
11.30459629 4.364464194
11.36132723 4.421779128
11.40292467 4.48409826
11.43406816 4.55968435
11.449 4.634657895
11.449 4.715342105
11.43406816 4.79031565
11.40292467 4.86590174
11.36128459 4.928284757
11.33745363 4.952466165
11.336 4.9536
11.332 4.958
11.328 4.9627
11.325 4.9678
11.322 4.9732
11.319 4.9789
11.318 4.9848
11.316 4.9908
11.316 4.9969
11.316 5.0031
11.316 5.0092
11.318 5.0152
11.319 5.0211
11.322 5.0268
11.325 5.0322
11.328 5.0373
11.332 5.042
11.336 5.0464
11.33745363 5.047533835
11.36128459 5.071715243
11.40292467 5.13409826
11.43406816 5.20968435
11.449 5.284657895
11.449 5.365342105
11.43406816 5.44031565
11.40292467 5.51590174
11.36132723 5.578220872
11.30459629 5.635535806
11.23920264 5.679131571
11.16539378 5.709721244
11.089 5.725
11.089 9.25
27.7 9.25
27.7 6.75
END
6 65 0 N 68 1 1 100 100 0 0 0 Y
USER_DAT FromImport
11.036 4.9497
11.009 4.947
10.982 4.9418
10.957 4.9339
10.932 4.9236
10.908 4.9109
10.885 4.8959
10.865 4.8788
10.845 4.8597
10.828 4.8388
10.813 4.8164
10.801 4.7926
10.79 4.7676
10.782 4.7418
10.777 4.7154
10.775 4.6885
10.775 4.6615
10.777 4.6346
10.782 4.6082
10.79 4.5824
10.801 4.5574
10.813 4.5336
10.828 4.5112
10.845 4.4903
10.865 4.4712
10.885 4.4541
10.908 4.4391
10.932 4.4264
10.957 4.4161
10.982 4.4082
11.009 4.403
11.036 4.4003
11.063 4.4003
11.09 4.403
11.116 4.4082
11.142 4.4161
11.167 4.4264
11.191 4.4391
11.213 4.4541
11.234 4.4712
11.253 4.4903
11.27 4.5112
11.285 4.5336
11.298 4.5574
11.308 4.5824
11.316 4.6082
11.321 4.6346
11.324 4.6615
11.324 4.6885
11.321 4.7154
11.316 4.7418
11.308 4.7676
11.298 4.7926
11.285 4.8164
11.27 4.8388
11.253 4.8597
11.234 4.8788
11.213 4.8959
11.191 4.9109
11.167 4.9236
11.142 4.9339
11.116 4.9418
11.09 4.947
11.063 4.9497
11.036 4.9497
END
6 65 0 N 69 1 1 100 100 0 0 0 Y
USER_DAT FromImport
11.036 5.5997
11.009 5.597
10.982 5.5918
10.957 5.5839
10.932 5.5736
10.908 5.5609
10.885 5.5459
10.865 5.5288
10.845 5.5097
10.828 5.4888
10.813 5.4664
10.801 5.4426
10.79 5.4176
10.782 5.3918
10.777 5.3654
10.775 5.3385
10.775 5.3115
10.777 5.2846
10.782 5.2582
10.79 5.2324
10.801 5.2074
10.813 5.1836
10.828 5.1612
10.845 5.1403
10.865 5.1212
10.885 5.1041
10.908 5.0891
10.932 5.0764
10.957 5.0661
10.982 5.0582
11.009 5.053
11.036 5.0503
11.063 5.0503
11.09 5.053
11.116 5.0582
11.142 5.0661
11.167 5.0764
11.191 5.0891
11.213 5.1041
11.234 5.1212
11.253 5.1403
11.27 5.1612
11.285 5.1836
11.298 5.2074
11.308 5.2324
11.316 5.2582
11.321 5.2846
11.324 5.3115
11.324 5.3385
11.321 5.3654
11.316 5.3918
11.308 5.4176
11.298 5.4426
11.285 5.4664
11.27 5.4888
11.253 5.5097
11.234 5.5288
11.213 5.5459
11.191 5.5609
11.167 5.5736
11.142 5.5839
11.116 5.5918
11.09 5.597
11.063 5.5997
11.036 5.5997
END
7 65 0 N 72 1 1 100 100 0 0 0 Y
USER_DAT FromImport
0.492 3.5247
0.465 3.522
0.438 3.5168
0.412 3.5089
0.387 3.4986
0.364 3.4859
0.341 3.4709
0.32 3.4538
0.301 3.4347
0.284 3.4138
0.269 3.3914
0.256 3.3676
0.246 3.3426
0.238 3.3168
0.233 3.2904
0.23 3.2635
0.23 3.2365
0.233 3.2096
0.238 3.1832
0.246 3.1574
0.256 3.1324
0.269 3.1086
0.284 3.0862
0.301 3.0653
0.32 3.0462
0.341 3.0291
0.364 3.0141
0.387 3.0014
0.412 2.9911
0.438 2.9832
0.465 2.978
0.492 2.9753
0.518 2.9753
0.545 2.978
0.572 2.9832
0.598 2.9911
0.623 3.0014
0.646 3.0141
0.669 3.0291
0.69 3.0462
0.709 3.0653
0.726 3.0862
0.741 3.1086
0.754 3.1324
0.764 3.1574
0.772 3.1832
0.777 3.2096
0.78 3.2365
0.78 3.2635
0.777 3.2904
0.772 3.3168
0.764 3.3426
0.754 3.3676
0.741 3.3914
0.726 3.4138
0.709 3.4347
0.69 3.4538
0.669 3.4709
0.646 3.4859
0.623 3.4986
0.598 3.5089
0.572 3.5168
0.545 3.522
0.518 3.5247
0.492 3.5247
END
7 65 0 N 73 1 1 100 100 0 0 0 Y
USER_DAT FromImport
0.492 6.2747
0.465 6.272
0.438 6.2668
0.412 6.2589
0.387 6.2486
0.364 6.2359
0.341 6.2209
0.32 6.2038
0.301 6.1847
0.284 6.1638
0.269 6.1414
0.256 6.1176
0.246 6.0926
0.238 6.0668
0.233 6.0404
0.23 6.0135
0.23 5.9865
0.233 5.9596
0.238 5.9332
0.246 5.9074
0.256 5.8824
0.269 5.8586
0.284 5.8362
0.301 5.8153
0.32 5.7962
0.341 5.7791
0.364 5.7641
0.387 5.7514
0.412 5.7411
0.438 5.7332
0.465 5.728
0.492 5.7253
0.518 5.7253
0.545 5.728
0.572 5.7332
0.598 5.7411
0.623 5.7514
0.646 5.7641
0.669 5.7791
0.69 5.7962
0.709 5.8153
0.726 5.8362
0.741 5.8586
0.754 5.8824
0.764 5.9074
0.772 5.9332
0.777 5.9596
0.78 5.9865
0.78 6.0135
0.777 6.0404
0.772 6.0668
0.764 6.0926
0.754 6.1176
0.741 6.1414
0.726 6.1638
0.709 6.1847
0.69 6.2038
0.669 6.2209
0.646 6.2359
0.623 6.2486
0.598 6.2589
0.572 6.2668
0.545 6.272
0.518 6.2747
0.492 6.2747
END
7 65 0 N 74 1 1 100 100 0 0 0 Y
USER_DAT FromImport
10.992 4.0247
10.965 4.022
10.938 4.0168
10.912 4.0089
10.887 3.9986
10.864 3.9859
10.841 3.9709
10.82 3.9538
10.801 3.9347
10.784 3.9138
10.769 3.8914
10.756 3.8676
10.746 3.8426
10.738 3.8168
10.733 3.7904
10.73 3.7635
10.73 3.7365
10.733 3.7096
10.738 3.6832
10.746 3.6574
10.756 3.6324
10.769 3.6086
10.784 3.5862
10.801 3.5653
10.82 3.5462
10.841 3.5291
10.864 3.5141
10.887 3.5014
10.912 3.4911
10.938 3.4832
10.965 3.478
10.992 3.4753
11.018 3.4753
11.045 3.478
11.072 3.4832
11.098 3.4911
11.123 3.5014
11.146 3.5141
11.169 3.5291
11.19 3.5462
11.209 3.5653
11.226 3.5862
11.241 3.6086
11.254 3.6324
11.264 3.6574
11.272 3.6832
11.277 3.7096
11.28 3.7365
11.28 3.7635
11.277 3.7904
11.272 3.8168
11.264 3.8426
11.254 3.8676
11.241 3.8914
11.226 3.9138
11.209 3.9347
11.19 3.9538
11.169 3.9709
11.146 3.9859
11.123 3.9986
11.098 4.0089
11.072 4.0168
11.045 4.022
11.018 4.0247
10.992 4.0247
END
7 65 0 N 75 1 1 100 100 0 0 0 Y
USER_DAT FromImport
10.992 6.5247
10.965 6.522
10.938 6.5168
10.912 6.5089
10.887 6.4986
10.864 6.4859
10.841 6.4709
10.82 6.4538
10.801 6.4347
10.784 6.4138
10.769 6.3914
10.756 6.3676
10.746 6.3426
10.738 6.3168
10.733 6.2904
10.73 6.2635
10.73 6.2365
10.733 6.2096
10.738 6.1832
10.746 6.1574
10.756 6.1324
10.769 6.1086
10.784 6.0862
10.801 6.0653
10.82 6.0462
10.841 6.0291
10.864 6.0141
10.887 6.0014
10.912 5.9911
10.938 5.9832
10.965 5.978
10.992 5.9753
11.018 5.9753
11.045 5.978
11.072 5.9832
11.098 5.9911
11.123 6.0014
11.146 6.0141
11.169 6.0291
11.19 6.0462
11.209 6.0653
11.226 6.0862
11.241 6.1086
11.254 6.1324
11.264 6.1574
11.272 6.1832
11.277 6.2096
11.28 6.2365
11.28 6.2635
11.277 6.2904
11.272 6.3168
11.264 6.3426
11.254 6.3676
11.241 6.3914
11.226 6.4138
11.209 6.4347
11.19 6.4538
11.169 6.4709
11.146 6.4859
11.123 6.4986
11.098 6.5089
11.072 6.5168
11.045 6.522
11.018 6.5247
10.992 6.5247
END
7 65 0 N 76 1 1 100 100 0 0 0 Y
USER_DAT FromImport
11.036 4.9497
11.009 4.947
10.982 4.9418
10.957 4.9339
10.932 4.9236
10.908 4.9109
10.885 4.8959
10.865 4.8788
10.845 4.8597
10.828 4.8388
10.813 4.8164
10.801 4.7926
10.79 4.7676
10.782 4.7418
10.777 4.7154
10.775 4.6885
10.775 4.6615
10.777 4.6346
10.782 4.6082
10.79 4.5824
10.801 4.5574
10.813 4.5336
10.828 4.5112
10.845 4.4903
10.865 4.4712
10.885 4.4541
10.908 4.4391
10.932 4.4264
10.957 4.4161
10.982 4.4082
11.009 4.403
11.036 4.4003
11.063 4.4003
11.09 4.403
11.116 4.4082
11.142 4.4161
11.167 4.4264
11.191 4.4391
11.213 4.4541
11.234 4.4712
11.253 4.4903
11.27 4.5112
11.285 4.5336
11.298 4.5574
11.308 4.5824
11.316 4.6082
11.321 4.6346
11.324 4.6615
11.324 4.6885
11.321 4.7154
11.316 4.7418
11.308 4.7676
11.298 4.7926
11.285 4.8164
11.27 4.8388
11.253 4.8597
11.234 4.8788
11.213 4.8959
11.191 4.9109
11.167 4.9236
11.142 4.9339
11.116 4.9418
11.09 4.947
11.063 4.9497
11.036 4.9497
END
7 65 0 N 77 1 1 100 100 0 0 0 Y
USER_DAT FromImport
11.036 5.5997
11.009 5.597
10.982 5.5918
10.957 5.5839
10.932 5.5736
10.908 5.5609
10.885 5.5459
10.865 5.5288
10.845 5.5097
10.828 5.4888
10.813 5.4664
10.801 5.4426
10.79 5.4176
10.782 5.3918
10.777 5.3654
10.775 5.3385
10.775 5.3115
10.777 5.2846
10.782 5.2582
10.79 5.2324
10.801 5.2074
10.813 5.1836
10.828 5.1612
10.845 5.1403
10.865 5.1212
10.885 5.1041
10.908 5.0891
10.932 5.0764
10.957 5.0661
10.982 5.0582
11.009 5.053
11.036 5.0503
11.063 5.0503
11.09 5.053
11.116 5.0582
11.142 5.0661
11.167 5.0764
11.191 5.0891
11.213 5.1041
11.234 5.1212
11.253 5.1403
11.27 5.1612
11.285 5.1836
11.298 5.2074
11.308 5.2324
11.316 5.2582
11.321 5.2846
11.324 5.3115
11.324 5.3385
11.321 5.3654
11.316 5.3918
11.308 5.4176
11.298 5.4426
11.285 5.4664
11.27 5.4888
11.253 5.5097
11.234 5.5288
11.213 5.5459
11.191 5.5609
11.167 5.5736
11.142 5.5839
11.116 5.5918
11.09 5.597
11.063 5.5997
11.036 5.5997
END
END GEO
OPT
MAX 100
END OPT
VARSWP
ENABLED Y
FREQ Y AY ABS_ENTRY 0.1 20.0 -1 300 
END
END VARSWP
```
