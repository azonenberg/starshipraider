akl-ad3-tip-v0p2.son:
```
FTYP SONPROJ 19 ! Sonnet Project File
VER 18.01
HEADER
LIC antikernel2.1.51012 90e2ba8817c1 havequick azonenberg Level3Gold
DAT 09/25/2021 05:49:49
BUILT_BY_CREATED dxf 18.01 09/25/2021 05:46:11
BUILT_BY_SAVED sonnet 18.01
MDATE 09/25/2021 05:49:49
HDATE 09/25/2021 05:49:49
ANN Created by dxfgeo, Sonnet Software Inc.
END HEADER
DIM
ANG DEG
CAP PF
CON /OH
FREQ GHZ
IND NH
LNG MM
RES OH
END DIM
CONTROL
VARSWP
OPTIONS  -d
SPEED 0
CACHE_ABS 2
Q_ACC N
END CONTROL
GEO
TMET "Free Space" 0 FREESPACE 376.7303136 0 0 0
BMET "Lossless" 0 SUP 0 0 0 0
MET "Copper 1oz thick" 1 TMM 58000000 0.5 0.035 2
MET "Unknown_metal" 1 VOL INF 0
BOX 2 50 30 1000 600 20 0
      5 1 1 0 0 0 0 "Air"
      0.035 4.3 1 0.02 0 0 0 "Soldermask"
      0.1016 3.2 1 0.002 0 0 0 "Panasonic R-F775"
TECHLAY METAL B.Cu L1D0 -1 -65534 
1 0 0 N 228 1 1 100 100 0 0 0 Y
END
END
TECHLAY VIA Via1 L2D0 -2 -65534 
VIA POLYGON
1 0 -1 N 272 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
END
END
LORGN 0 30 U 
NUM 213
1 5 0 N 1 1 1 100 100 0 0 0 Y
TLAYNAM B.Cu INH
39.475 26.975
39.475 26.475
40.075 26.475
40.075 26.975
39.475 26.975
END
1 5 0 N 2 1 1 100 100 0 0 0 Y
TLAYNAM B.Cu INH
40.575 26.975
40.575 26.475
41.175 26.475
41.175 26.975
40.575 26.975
END
1 24 0 N 3 1 1 100 100 0 0 0 Y
TLAYNAM B.Cu INH
44.241 29.381
42.219 27.359
42.543 27.035
42.334 26.825
42.175 26.825
42.175 26.975
41.675 26.975
41.675 26.475
42.175 26.475
42.175 26.625
42.38 26.625
42.39 26.626
42.399 26.628
42.409 26.631
42.418 26.634
42.426 26.639
42.435 26.645
42.442 26.651
42.449 26.658
42.455 26.665
42.684 26.894
43.209 26.369
45.231 28.391
44.241 29.381
END
1 125 0 N 4 1 1 100 100 0 0 0 Y
TLAYNAM B.Cu INH
17.295 27.075
17.285 27.074
17.276 27.072
17.266 27.069
17.257 27.066
17.249 27.061
17.24 27.055
17.233 27.049
16.151 25.967
16.145 25.96
16.139 25.951
16.134 25.943
16.131 25.934
16.128 25.924
16.126 25.915
16.125 25.905
16.125 17.016
15.684 16.575
6.016 16.575
4.042 18.549
4.035 18.555
4.026 18.561
4.018 18.566
4.009 18.569
3.999 18.572
3.99 18.574
3.98 18.575
2.47 18.575
2.46 18.574
2.451 18.572
2.441 18.569
2.432 18.566
2.424 18.561
2.415 18.555
2.408 18.549
1.151 17.292
1.145 17.285
1.139 17.276
1.134 17.268
1.131 17.259
1.128 17.249
1.126 17.24
1.125 17.23
1.125 15.72
1.126 15.71
1.128 15.701
1.131 15.691
1.134 15.682
1.139 15.674
1.145 15.665
1.151 15.658
1.658 15.151
1.665 15.145
1.674 15.139
1.682 15.134
1.691 15.131
1.701 15.128
1.71 15.126
1.72 15.125
1.875 15.125
1.875 15.075
3.375 15.075
3.375 15.375
1.875 15.375
1.875 15.325
1.766 15.325
1.325 15.766
1.325 17.184
2.516 18.375
3.934 18.375
5.908 16.401
5.915 16.395
5.924 16.389
5.932 16.384
5.941 16.381
5.951 16.378
5.96 16.376
5.97 16.375
15.73 16.375
15.74 16.376
15.749 16.378
15.759 16.381
15.768 16.384
15.776 16.389
15.785 16.395
15.792 16.401
15.799 16.408
15.805 16.415
16.285 16.895
16.292 16.901
16.299 16.908
16.305 16.915
16.311 16.924
16.316 16.932
16.319 16.941
16.322 16.951
16.324 16.96
16.325 16.97
16.325 25.859
17.341 26.875
37.734 26.875
37.958 26.651
37.965 26.645
37.974 26.639
37.982 26.634
37.991 26.631
38.001 26.628
38.01 26.626
38.02 26.625
38.475 26.625
38.475 26.475
38.975 26.475
38.975 26.975
38.475 26.975
38.475 26.825
38.066 26.825
37.842 27.049
37.835 27.055
37.826 27.061
37.818 27.066
37.809 27.069
37.799 27.072
37.79 27.074
37.78 27.075
17.295 27.075
END
1 5 0 N 5 1 1 100 100 0 0 0 Y
TLAYNAM B.Cu INH
39.475 2.975
39.475 2.475
40.075 2.475
40.075 2.975
39.475 2.975
END
1 5 0 N 6 1 1 100 100 0 0 0 Y
TLAYNAM B.Cu INH
40.575 2.975
40.575 2.475
41.175 2.475
41.175 2.975
40.575 2.975
END
1 125 0 N 7 1 1 100 100 0 0 0 Y
TLAYNAM B.Cu INH
1.875 14.375
1.875 14.325
1.67 14.325
1.66 14.324
1.651 14.322
1.641 14.319
1.632 14.316
1.624 14.311
1.615 14.305
1.608 14.299
1.151 13.842
1.145 13.835
1.139 13.826
1.134 13.818
1.131 13.809
1.128 13.799
1.126 13.79
1.125 13.78
1.125 12.22
1.126 12.21
1.128 12.201
1.131 12.191
1.134 12.182
1.139 12.174
1.145 12.165
1.151 12.158
2.408 10.901
2.415 10.895
2.424 10.889
2.432 10.884
2.441 10.881
2.451 10.878
2.46 10.876
2.47 10.875
3.98 10.875
3.99 10.876
3.999 10.878
4.009 10.881
4.018 10.884
4.026 10.889
4.035 10.895
4.042 10.901
4.049 10.908
4.055 10.915
6.016 12.875
15.684 12.875
16.125 12.434
16.125 3.545
16.126 3.535
16.128 3.526
16.131 3.516
16.134 3.507
16.139 3.499
16.145 3.49
16.151 3.483
17.233 2.401
17.24 2.395
17.249 2.389
17.257 2.384
17.266 2.381
17.276 2.378
17.285 2.376
17.295 2.375
38.03 2.375
38.04 2.376
38.049 2.378
38.059 2.381
38.068 2.384
38.076 2.389
38.085 2.395
38.092 2.401
38.099 2.408
38.105 2.415
38.316 2.625
38.475 2.625
38.475 2.475
38.975 2.475
38.975 2.975
38.475 2.975
38.475 2.825
38.27 2.825
38.26 2.824
38.251 2.822
38.241 2.819
38.232 2.816
38.224 2.811
38.215 2.805
38.208 2.799
37.984 2.575
17.341 2.575
16.325 3.591
16.325 12.48
16.324 12.49
16.322 12.499
16.319 12.509
16.316 12.518
16.311 12.526
16.305 12.535
16.299 12.542
15.792 13.049
15.785 13.055
15.776 13.061
15.768 13.066
15.759 13.069
15.749 13.072
15.74 13.074
15.73 13.075
5.97 13.075
5.96 13.074
5.951 13.072
5.941 13.069
5.932 13.066
5.924 13.061
5.915 13.055
5.908 13.049
3.934 11.075
2.516 11.075
1.325 12.266
1.325 13.734
1.716 14.125
1.875 14.125
1.875 14.075
3.375 14.075
3.375 14.375
1.875 14.375
END
1 1538 0 N 8 1 1 100 100 0 0 0 Y
TLAYNAM B.Cu INH
16.369 28.226
16.358 28.224
16.348 28.222
16.337 28.219
16.327 28.215
16.317 28.21
16.299 28.196
16.291 28.189
16.287 28.185
14.754 26.651
14.747 26.642
14.741 26.633
14.736 26.624
14.731 26.613
14.728 26.603
14.726 26.592
14.725 26.581
14.725 17.987
14.727 17.979
14.727 17.978
14.725 17.963
14.725 17.727
14.724 17.726
14.487 17.726
14.478 17.724
14.473 17.724
14.463 17.726
7.487 17.726
7.478 17.724
7.473 17.724
7.463 17.726
7.226 17.726
7.226 17.963
7.224 17.972
7.224 17.977
7.226 17.987
7.226 18.581
7.224 18.592
7.222 18.602
7.219 18.613
7.215 18.623
7.21 18.633
7.196 18.651
7.189 18.659
7.184 18.663
6.151 19.696
6.133 19.71
6.123 19.715
6.113 19.719
6.103 19.722
6.081 19.726
1.369 19.726
1.358 19.724
1.348 19.722
1.337 19.719
1.327 19.715
1.317 19.71
1.299 19.696
0.793 19.19
0.786 19.182
0.254 18.65
0.247 18.642
0.241 18.633
0.236 18.623
0.232 18.613
0.228 18.602
0.226 18.591
0.225 18.582
0.225 10.869
0.227 10.858
0.229 10.848
0.232 10.837
0.236 10.827
0.241 10.817
0.255 10.799
1.3 9.754
1.308 9.747
1.317 9.741
1.327 9.736
1.337 9.732
1.348 9.728
1.359 9.726
1.368 9.725
6.08 9.725
6.09 9.727
6.092 9.727
6.102 9.729
6.113 9.732
6.123 9.736
6.133 9.741
6.151 9.755
6.158 9.762
7.184 10.789
7.189 10.792
7.196 10.799
7.21 10.817
7.215 10.827
7.219 10.837
7.222 10.848
7.224 10.858
7.226 10.869
7.226 11.463
7.224 11.472
7.224 11.477
7.226 11.487
7.226 11.725
7.463 11.725
7.471 11.727
7.472 11.727
7.487 11.725
14.463 11.725
14.471 11.727
14.472 11.727
14.487 11.725
14.723 11.725
14.725 11.724
14.725 11.487
14.727 11.479
14.727 11.478
14.725 11.463
14.725 3.119
14.727 3.108
14.729 3.098
14.732 3.087
14.736 3.077
14.741 3.067
14.755 3.049
14.762 3.041
14.766 3.038
16.55 1.254
16.559 1.247
16.561 1.246
16.567 1.241
16.577 1.236
16.588 1.231
16.598 1.228
16.609 1.226
16.618 1.225
37.463 1.225
37.471 1.227
37.472 1.227
37.487 1.225
37.869 1.225
37.88 1.227
37.89 1.229
37.901 1.232
37.911 1.236
37.921 1.241
37.939 1.255
37.946 1.262
37.96 1.28
37.965 1.29
37.969 1.3
37.972 1.311
37.974 1.321
37.976 1.332
37.976 2.044
37.974 2.055
37.972 2.065
37.969 2.076
37.965 2.086
37.96 2.096
37.946 2.114
37.939 2.121
37.921 2.135
37.911 2.14
37.901 2.144
37.89 2.147
37.88 2.149
37.869 2.151
17.315 2.151
17.297 2.149
17.296 2.149
17.285 2.151
17.273 2.151
17.233 2.156
17.178 2.172
17.117 2.204
17.105 2.214
17.098 2.221
17.065 2.248
17.064 2.249
17.059 2.256
16.006 3.309
16 3.314
15.997 3.316
15.995 3.317
15.994 3.318
15.994 3.319
15.99 3.323
15.984 3.331
15.981 3.334
15.954 3.368
15.923 3.424
15.906 3.483
15.899 3.552
15.899 3.554
15.901 3.565
15.9 12.288
15.901 12.3
15.899 12.311
15.897 12.321
15.894 12.332
15.89 12.342
15.885 12.352
15.871 12.37
15.62 12.621
15.602 12.635
15.592 12.64
15.582 12.644
15.572 12.647
15.55 12.651
6.15 12.651
6.139 12.649
6.129 12.647
6.118 12.644
6.108 12.64
6.098 12.635
6.08 12.621
5.55 12.091
5.536 12.073
5.531 12.063
5.527 12.053
5.524 12.042
5.524 12.041
5.523 12.038
5.521 12.028
5.521 12.025
5.52 12.021
5.52 12.009
5.521 12.002
5.522 11.998
5.522 11.994
5.525 11.984
5.528 11.973
5.536 11.957
5.537 11.956
5.538 11.954
5.544 11.944
5.552 11.936
5.568 11.922
5.578 11.916
5.588 11.911
5.598 11.907
5.609 11.904
5.619 11.902
5.779 11.891
5.951 11.844
6.112 11.763
6.119 11.758
6.142 11.694
5.987 11.539
5.959 11.558
5.903 11.588
5.844 11.612
5.783 11.631
5.72 11.643
5.657 11.649
5.593 11.649
5.53 11.643
5.467 11.631
5.406 11.612
5.347 11.588
5.291 11.558
5.238 11.522
5.188 11.482
5.143 11.437
5.103 11.387
5.067 11.334
5.037 11.278
5.013 11.219
4.994 11.158
4.982 11.095
4.976 11.032
4.976 10.968
4.982 10.905
4.994 10.842
5.013 10.781
5.037 10.722
5.067 10.666
5.086 10.638
4.932 10.484
4.871 10.505
4.798 10.634
4.743 10.8
4.721 10.975
4.721 10.98
4.722 10.988
4.722 11
4.72 11.011
4.718 11.021
4.714 11.032
4.71 11.042
4.708 11.045
4.706 11.049
4.701 11.055
4.698 11.06
4.691 11.069
4.683 11.076
4.674 11.083
4.67 11.086
4.667 11.088
4.655 11.094
4.649 11.096
4.647 11.097
4.646 11.097
4.644 11.098
4.634 11.101
4.623 11.103
4.612 11.104
4.603 11.104
4.594 11.102
4.59 11.102
4.584 11.101
4.582 11.1
4.571 11.097
4.57 11.096
4.568 11.096
4.566 11.095
4.561 11.093
4.551 11.088
4.549 11.086
4.545 11.083
4.54 11.08
4.535 11.076
4.216 10.757
4.209 10.748
4.206 10.744
4.206 10.743
4.157 10.703
4.101 10.673
4.041 10.656
4.002 10.651
3.99 10.651
3.972 10.649
3.971 10.649
3.96 10.651
2.49 10.651
2.472 10.649
2.471 10.649
2.46 10.651
2.448 10.651
2.408 10.656
2.353 10.672
2.292 10.704
2.244 10.743
2.243 10.744
2.234 10.756
1.006 11.984
1 11.989
0.997 11.991
0.995 11.992
0.994 11.993
0.994 11.994
0.99 11.998
0.984 12.006
0.981 12.009
0.954 12.043
0.924 12.099
0.912 12.136
0.909 12.148
0.907 12.153
0.906 12.156
0.905 12.158
0.903 12.18
0.901 12.191
0.898 12.223
0.899 12.229
0.901 12.24
0.9 13.748
0.901 13.76
0.899 13.778
0.899 13.779
0.901 13.79
0.901 13.802
0.906 13.842
0.922 13.897
0.954 13.958
0.993 14.006
0.994 14.007
1.006 14.016
1.434 14.444
1.439 14.45
1.441 14.453
1.444 14.456
1.487 14.491
1.504 14.502
1.505 14.503
1.548 14.526
1.566 14.531
1.577 14.536
1.586 14.541
1.596 14.547
1.604 14.554
1.612 14.562
1.619 14.57
1.649 14.6
1.864 14.6
1.869 14.601
1.875 14.601
1.875 14.575
3.375 14.575
3.375 14.601
3.381 14.601
3.386 14.6
3.601 14.6
3.626 14.575
3.622 14.528
3.607 14.479
3.607 14.478
3.606 14.478
3.605 14.473
3.603 14.469
3.603 14.468
3.6 14.458
3.596 14.436
3.597 14.424
3.601 14.38
3.601 14.069
3.596 14.027
3.596 14.014
3.597 14.003
3.599 13.992
3.607 13.972
3.608 13.97
3.608 13.969
3.621 13.927
3.626 13.875
3.602 13.851
3.386 13.851
3.375 13.85
3.375 13.875
1.875 13.875
1.875 13.575
2.5 13.575
2.5 13.391
2.435 13.326
1.871 13.324
1.869 13.324
1.828 13.328
1.777 13.344
1.739 13.363
1.737 13.365
1.73 13.371
1.721 13.377
1.711 13.382
1.701 13.386
1.69 13.39
1.679 13.392
1.67 13.393
1.657 13.393
1.646 13.392
1.635 13.39
1.615 13.382
1.605 13.377
1.596 13.371
1.587 13.364
1.579 13.356
1.572 13.347
1.566 13.338
1.561 13.328
1.557 13.318
1.554 13.308
1.551 13.297
1.55 13.286
1.55 12.4
1.552 12.389
1.554 12.379
1.554 12.378
1.557 12.368
1.561 12.358
1.566 12.348
1.58 12.33
1.587 12.322
1.591 12.319
2.581 11.329
2.59 11.322
2.592 11.321
2.598 11.316
2.604 11.313
2.609 11.31
2.619 11.306
2.629 11.303
2.64 11.301
2.649 11.3
3.526 11.3
3.537 11.302
3.547 11.304
3.548 11.304
3.558 11.307
3.568 11.311
3.578 11.316
3.596 11.33
3.604 11.337
3.611 11.346
3.617 11.355
3.622 11.365
3.626 11.375
3.629 11.386
3.632 11.396
3.633 11.407
3.633 11.419
3.632 11.43
3.629 11.44
3.626 11.451
3.622 11.461
3.617 11.471
3.611 11.48
3.604 11.489
3.596 11.496
3.578 11.51
3.568 11.515
3.558 11.519
3.548 11.522
3.547 11.522
3.536 11.524
3.346 11.562
3.174 11.633
3.021 11.736
2.911 11.846
2.906 11.854
2.887 11.876
2.876 11.887
2.782 12.027
2.71 12.202
2.676 12.373
2.676 12.573
2.712 12.754
2.783 12.926
2.886 13.079
2.943 13.136
2.95 13.145
2.956 13.154
2.962 13.164
2.966 13.174
2.969 13.184
2.971 13.195
2.973 13.217
2.969 13.239
2.966 13.25
2.962 13.26
2.957 13.27
2.951 13.279
2.944 13.287
2.936 13.295
2.927 13.302
2.918 13.308
2.908 13.314
2.898 13.318
2.888 13.321
2.877 13.323
2.866 13.324
2.854 13.324
2.775 13.325
2.751 13.349
2.751 13.575
3.375 13.575
3.375 13.6
3.601 13.6
3.626 13.575
3.624 13.554
3.624 13.553
3.622 13.542
3.623 13.53
3.624 13.519
3.626 13.509
3.629 13.498
3.633 13.488
3.638 13.478
3.645 13.469
3.652 13.461
3.652 13.46
3.659 13.453
3.66 13.453
3.668 13.446
3.677 13.439
3.687 13.434
3.697 13.43
3.708 13.427
3.719 13.425
3.905 13.388
4.076 13.317
4.229 13.214
4.361 13.082
4.468 12.923
4.54 12.748
4.575 12.572
4.575 12.377
4.564 12.319
4.563 12.317
4.561 12.307
4.56 12.296
4.559 12.284
4.561 12.273
4.563 12.263
4.566 12.252
4.57 12.242
4.575 12.232
4.589 12.214
4.596 12.206
4.605 12.199
4.614 12.193
4.624 12.188
4.634 12.184
4.645 12.181
4.655 12.179
4.666 12.177
4.678 12.177
4.689 12.179
4.699 12.181
4.71 12.184
4.72 12.188
4.73 12.193
4.739 12.199
4.748 12.206
4.756 12.214
4.759 12.219
5.668 13.128
5.676 13.135
5.683 13.143
5.689 13.153
5.694 13.162
5.699 13.173
5.702 13.183
5.704 13.194
5.705 13.205
5.705 13.216
5.704 13.227
5.702 13.238
5.699 13.248
5.694 13.259
5.689 13.268
5.683 13.278
5.676 13.286
5.667 13.295
5.659 13.302
5.65 13.308
5.64 13.313
5.63 13.317
5.62 13.32
5.609 13.322
5.607 13.322
5.597 13.324
5.578 13.323
5.528 13.328
5.477 13.344
5.438 13.364
5.393 13.402
5.368 13.432
5.341 13.483
5.329 13.523
5.324 13.574
5.35 13.6
5.563 13.6
5.574 13.602
5.575 13.602
5.575 13.575
7.075 13.575
7.075 13.601
7.076 13.601
7.087 13.6
7.203 13.6
7.204 13.597
7.218 13.571
7.234 13.546
7.253 13.524
7.274 13.503
7.296 13.484
7.306 13.477
7.306 13.476
7.305 13.475
7.302 13.471
7.297 13.461
7.293 13.451
7.29 13.44
7.288 13.43
7.286 13.419
7.286 13.407
7.288 13.396
7.29 13.386
7.293 13.375
7.297 13.365
7.302 13.355
7.316 13.337
7.324 13.329
7.333 13.322
7.335 13.321
7.341 13.316
7.351 13.311
7.361 13.307
7.383 13.301
7.392 13.3
15.71 13.3
15.722 13.302
15.729 13.302
15.738 13.3
15.748 13.3
15.786 13.296
15.847 13.278
15.908 13.246
15.956 13.207
15.957 13.206
15.966 13.194
16.444 12.716
16.45 12.711
16.453 12.709
16.456 12.706
16.497 12.657
16.527 12.601
16.544 12.541
16.55 12.49
16.551 12.48
16.552 12.476
16.552 12.471
16.55 12.462
16.55 3.726
16.552 3.716
16.552 3.714
16.554 3.704
16.557 3.693
16.561 3.683
16.566 3.673
16.58 3.655
17.406 2.829
17.415 2.822
17.417 2.821
17.423 2.816
17.429 2.813
17.434 2.81
17.444 2.806
17.454 2.803
17.465 2.801
17.474 2.8
37.85 2.8
37.861 2.802
37.871 2.804
37.882 2.807
37.892 2.811
37.902 2.816
37.92 2.83
37.927 2.837
37.93 2.841
37.934 2.845
37.939 2.848
37.946 2.855
37.96 2.873
37.965 2.883
37.969 2.893
37.972 2.904
37.974 2.914
37.976 2.925
37.976 3.619
37.974 3.63
37.972 3.64
37.969 3.651
37.965 3.661
37.96 3.671
37.946 3.689
37.939 3.696
37.921 3.71
37.911 3.715
37.901 3.719
37.89 3.722
37.88 3.724
37.869 3.726
18.738 3.726
18.73 3.724
18.723 3.724
18.713 3.726
18.701 3.726
18.674 3.729
18.627 3.744
18.588 3.764
18.557 3.789
18.549 3.796
18.546 3.798
18.544 3.8
18.539 3.806
18.539 3.807
17.807 4.539
17.798 4.546
17.796 4.548
17.789 4.556
17.789 4.557
17.788 4.558
17.767 4.585
17.743 4.628
17.741 4.633
17.74 4.634
17.729 4.673
17.726 4.701
17.725 4.713
17.725 4.714
17.724 4.724
17.724 4.727
17.726 4.737
17.726 13.081
17.724 13.092
17.722 13.102
17.719 13.113
17.715 13.123
17.71 13.133
17.696 13.151
17.689 13.159
17.684 13.163
16.651 14.196
16.633 14.21
16.623 14.215
16.613 14.219
16.603 14.222
16.581 14.226
7.987 14.226
7.978 14.224
7.973 14.224
7.963 14.226
7.726 14.226
7.726 14.463
7.724 14.472
7.724 14.477
7.726 14.487
7.726 14.963
7.724 14.972
7.724 14.977
7.726 14.987
7.726 15.225
7.963 15.225
7.971 15.227
7.972 15.227
7.987 15.225
16.581 15.225
16.592 15.227
16.602 15.229
16.613 15.232
16.623 15.236
16.633 15.241
16.651 15.255
16.659 15.262
16.662 15.267
17.684 16.289
17.689 16.292
17.696 16.299
17.71 16.317
17.715 16.327
17.719 16.337
17.722 16.348
17.724 16.358
17.726 16.369
17.726 24.713
17.724 24.722
17.724 24.728
17.728 24.772
17.744 24.823
17.764 24.862
17.789 24.893
17.796 24.901
17.798 24.904
17.8 24.906
17.806 24.911
17.807 24.911
18.539 25.643
18.546 25.652
18.548 25.654
18.556 25.661
18.557 25.661
18.558 25.662
18.585 25.683
18.633 25.709
18.669 25.72
18.713 25.725
18.724 25.726
18.725 25.726
18.737 25.725
37.869 25.725
37.88 25.727
37.89 25.729
37.901 25.732
37.911 25.736
37.921 25.741
37.939 25.755
37.946 25.762
37.96 25.78
37.965 25.79
37.969 25.8
37.972 25.811
37.974 25.821
37.976 25.832
37.976 26.323
37.974 26.334
37.972 26.344
37.972 26.345
37.969 26.356
37.965 26.366
37.96 26.376
37.953 26.385
37.946 26.393
37.939 26.4
37.939 26.401
37.93 26.408
37.921 26.414
37.911 26.419
37.904 26.422
37.901 26.424
37.898 26.425
37.842 26.454
37.794 26.493
37.793 26.494
37.784 26.506
37.68 26.61
37.677 26.614
37.67 26.621
37.652 26.635
37.642 26.64
37.632 26.644
37.621 26.647
37.611 26.649
37.6 26.651
17.475 26.651
17.464 26.649
17.454 26.647
17.443 26.644
17.433 26.64
17.423 26.635
17.405 26.621
16.579 25.795
16.572 25.786
16.566 25.777
16.56 25.767
16.556 25.757
16.553 25.747
16.551 25.736
16.55 25.725
16.55 16.99
16.552 16.978
16.552 16.971
16.55 16.962
16.55 16.952
16.546 16.914
16.528 16.853
16.496 16.792
16.457 16.744
16.456 16.743
16.444 16.734
15.966 16.256
15.961 16.25
15.959 16.247
15.956 16.244
15.907 16.203
15.851 16.173
15.791 16.156
15.752 16.151
15.74 16.151
15.722 16.149
15.721 16.149
15.71 16.151
7.393 16.151
7.382 16.149
7.372 16.147
7.361 16.144
7.351 16.14
7.341 16.135
7.323 16.121
7.316 16.114
7.302 16.096
7.297 16.086
7.293 16.076
7.29 16.065
7.288 16.055
7.287 16.044
7.286 16.032
7.288 16.021
7.29 16.011
7.293 16
7.297 15.99
7.303 15.98
7.306 15.973
7.296 15.966
7.274 15.947
7.253 15.926
7.234 15.904
7.218 15.879
7.204 15.853
7.203 15.851
7.087 15.851
7.076 15.849
7.075 15.849
7.075 15.875
5.575 15.875
5.575 15.849
5.574 15.849
5.563 15.851
5.349 15.851
5.324 15.876
5.328 15.922
5.344 15.973
5.364 16.012
5.402 16.057
5.432 16.082
5.483 16.109
5.523 16.121
5.578 16.127
5.581 16.127
5.583 16.126
5.599 16.126
5.608 16.127
5.63 16.133
5.64 16.137
5.65 16.142
5.659 16.148
5.667 16.155
5.675 16.163
5.689 16.181
5.694 16.191
5.698 16.201
5.701 16.211
5.701 16.212
5.703 16.222
5.705 16.233
5.705 16.246
5.704 16.255
5.698 16.277
5.694 16.287
5.689 16.297
5.683 16.306
5.676 16.314
4.758 17.232
4.755 17.236
4.748 17.243
4.747 17.243
4.739 17.25
4.73 17.257
4.72 17.262
4.71 17.266
4.699 17.269
4.689 17.271
4.678 17.273
4.666 17.272
4.655 17.271
4.644 17.269
4.634 17.266
4.624 17.262
4.614 17.257
4.608 17.253
4.604 17.25
4.596 17.243
4.588 17.235
4.581 17.227
4.578 17.221
4.575 17.218
4.57 17.208
4.565 17.197
4.562 17.187
4.56 17.176
4.559 17.167
4.559 17.154
4.56 17.143
4.562 17.132
4.565 17.122
4.565 17.121
4.575 17.073
4.575 16.877
4.54 16.701
4.467 16.524
4.364 16.371
4.232 16.239
4.073 16.132
3.899 16.06
3.729 16.027
3.722 16.026
3.718 16.025
3.708 16.023
3.697 16.02
3.687 16.016
3.677 16.011
3.668 16.004
3.66 15.997
3.659 15.997
3.652 15.99
3.638 15.972
3.633 15.962
3.629 15.952
3.626 15.941
3.624 15.931
3.623 15.92
3.622 15.908
3.625 15.874
3.602 15.851
3.375 15.851
3.375 15.875
2.751 15.875
2.751 16.101
2.775 16.125
2.854 16.126
2.866 16.126
2.877 16.127
2.887 16.129
2.898 16.132
2.908 16.136
2.918 16.141
2.927 16.148
2.935 16.155
2.936 16.155
2.943 16.162
2.957 16.18
2.962 16.19
2.966 16.2
2.969 16.211
2.971 16.221
2.973 16.232
2.973 16.244
2.969 16.266
2.968 16.269
2.966 16.276
2.962 16.286
2.957 16.296
2.956 16.297
2.955 16.299
2.95 16.306
2.943 16.314
2.889 16.368
2.782 16.527
2.71 16.702
2.676 16.873
2.676 17.073
2.712 17.254
2.783 17.426
2.873 17.56
2.887 17.574
2.906 17.596
2.911 17.604
3.018 17.711
3.177 17.818
3.352 17.89
3.526 17.925
3.537 17.927
3.547 17.929
3.548 17.929
3.558 17.932
3.568 17.936
3.578 17.941
3.587 17.947
3.596 17.954
3.604 17.962
3.611 17.971
3.617 17.98
3.622 17.99
3.63 18.01
3.632 18.021
3.633 18.032
3.633 18.045
3.632 18.054
3.63 18.065
3.626 18.076
3.622 18.086
3.617 18.096
3.611 18.105
3.604 18.113
3.596 18.121
3.578 18.135
3.568 18.14
3.558 18.144
3.548 18.147
3.526 18.151
2.65 18.151
2.639 18.149
2.629 18.147
2.628 18.147
2.618 18.144
2.608 18.14
2.598 18.135
2.58 18.121
2.572 18.114
2.568 18.11
1.579 17.12
1.572 17.111
1.566 17.102
1.56 17.092
1.556 17.082
1.553 17.072
1.551 17.061
1.55 17.05
1.55 16.164
1.552 16.153
1.554 16.143
1.554 16.142
1.557 16.132
1.561 16.122
1.566 16.112
1.58 16.094
1.587 16.086
1.596 16.079
1.605 16.073
1.615 16.068
1.625 16.064
1.636 16.061
1.646 16.058
1.657 16.057
1.669 16.057
1.68 16.058
1.69 16.061
1.701 16.064
1.711 16.068
1.721 16.073
1.73 16.079
1.737 16.085
1.739 16.086
1.783 16.109
1.823 16.121
1.881 16.127
2.434 16.125
2.5 16.059
2.5 15.875
1.875 15.875
1.875 15.575
3.375 15.575
3.375 15.601
3.381 15.601
3.386 15.6
3.601 15.6
3.626 15.575
3.622 15.528
3.607 15.479
3.607 15.478
3.606 15.478
3.605 15.473
3.603 15.469
3.603 15.468
3.6 15.458
3.596 15.436
3.597 15.424
3.601 15.38
3.601 15.069
3.596 15.027
3.596 15.014
3.597 15.003
3.599 14.992
3.607 14.972
3.608 14.97
3.608 14.969
3.621 14.927
3.626 14.875
3.602 14.851
3.386 14.851
3.375 14.85
3.375 14.875
1.875 14.875
1.875 14.849
1.873 14.849
1.864 14.851
1.649 14.851
1.618 14.882
1.617 14.885
1.608 14.903
1.607 14.904
1.6 14.913
1.597 14.916
1.595 14.919
1.585 14.929
1.576 14.936
1.57 14.94
1.567 14.941
1.557 14.946
1.542 14.955
1.527 14.966
1.517 14.975
1.505 14.985
1.496 14.991
1.493 14.994
1.484 15.006
1.006 15.484
1 15.489
0.997 15.491
0.994 15.494
0.953 15.543
0.923 15.599
0.906 15.659
0.901 15.698
0.901 15.71
0.899 15.728
0.899 15.729
0.9 15.74
0.9 15.752
0.901 17.198
0.901 17.209
0.899 17.219
0.899 17.22
0.898 17.226
0.898 17.227
0.899 17.229
0.9 17.241
0.905 17.289
0.906 17.292
0.906 17.294
0.922 17.347
0.954 17.408
0.955 17.41
0.956 17.411
0.993 17.456
0.994 17.457
1.006 17.466
2.234 18.694
2.239 18.7
2.241 18.703
2.244 18.706
2.293 18.747
2.349 18.777
2.409 18.794
2.46 18.8
2.47 18.801
2.474 18.802
2.479 18.802
2.488 18.8
3.96 18.8
3.972 18.802
3.979 18.802
3.988 18.8
3.998 18.8
4.036 18.796
4.097 18.778
4.158 18.746
4.206 18.707
4.207 18.706
4.216 18.694
4.535 18.375
4.541 18.37
4.546 18.366
4.548 18.365
4.553 18.361
4.563 18.356
4.573 18.352
4.575 18.352
4.576 18.351
4.587 18.348
4.597 18.346
4.609 18.345
4.631 18.347
4.637 18.349
4.638 18.349
4.649 18.352
4.65 18.353
4.652 18.353
4.654 18.354
4.659 18.356
4.669 18.361
4.673 18.365
4.681 18.369
4.694 18.382
4.699 18.388
4.703 18.393
4.704 18.396
4.708 18.4
4.713 18.41
4.717 18.42
4.717 18.422
4.718 18.423
4.721 18.434
4.723 18.444
4.734 18.604
4.781 18.776
4.862 18.937
4.867 18.944
4.931 18.967
5.086 18.812
5.067 18.784
5.037 18.728
5.013 18.669
4.994 18.608
4.982 18.545
4.976 18.482
4.976 18.418
4.982 18.355
4.994 18.292
5.013 18.231
5.037 18.172
5.067 18.116
5.103 18.063
5.143 18.013
5.188 17.968
5.238 17.928
5.291 17.892
5.347 17.862
5.406 17.838
5.467 17.819
5.53 17.807
5.593 17.801
5.657 17.801
5.72 17.807
5.783 17.819
5.844 17.838
5.903 17.862
5.959 17.892
5.987 17.911
6.141 17.757
6.12 17.696
5.991 17.623
5.825 17.568
5.65 17.546
5.647 17.546
5.642 17.547
5.625 17.547
5.614 17.545
5.604 17.543
5.593 17.539
5.583 17.535
5.58 17.533
5.576 17.531
5.57 17.526
5.565 17.523
5.556 17.516
5.549 17.508
5.542 17.499
5.539 17.495
5.537 17.492
5.531 17.48
5.529 17.475
5.528 17.472
5.528 17.471
5.527 17.469
5.524 17.459
5.522 17.448
5.522 17.443
5.521 17.44
5.521 17.437
5.523 17.415
5.524 17.41
5.525 17.407
5.528 17.396
5.529 17.395
5.529 17.393
5.53 17.391
5.532 17.386
5.537 17.376
5.539 17.374
5.542 17.37
5.545 17.365
5.549 17.36
6.08 16.829
6.089 16.822
6.098 16.816
6.108 16.81
6.118 16.806
6.128 16.803
6.139 16.801
6.15 16.8
15.549 16.8
15.559 16.802
15.561 16.802
15.571 16.804
15.582 16.807
15.592 16.811
15.602 16.816
15.62 16.83
15.627 16.837
15.859 17.07
15.864 17.073
15.871 17.08
15.885 17.098
15.89 17.108
15.894 17.118
15.897 17.129
15.899 17.139
15.9 17.15
15.9 17.162
15.901 25.873
15.901 25.884
15.899 25.894
15.898 25.901
15.898 25.904
15.904 25.962
15.922 26.022
15.954 26.083
15.955 26.084
15.993 26.131
15.994 26.132
16.006 26.141
17.059 27.194
17.064 27.2
17.066 27.203
17.067 27.205
17.068 27.206
17.07 27.207
17.073 27.21
17.081 27.216
17.081 27.217
17.082 27.217
17.083 27.218
17.091 27.224
17.099 27.231
17.121 27.248
17.174 27.277
17.234 27.294
17.285 27.3
17.295 27.301
17.299 27.302
17.304 27.302
17.313 27.3
37.76 27.3
37.772 27.302
37.779 27.302
37.788 27.3
37.802 27.3
37.835 27.296
37.846 27.294
37.857 27.293
37.87 27.293
37.879 27.294
37.89 27.296
37.901 27.299
37.921 27.309
37.93 27.315
37.938 27.322
37.946 27.33
37.953 27.338
37.956 27.342
37.96 27.348
37.963 27.354
37.965 27.357
37.969 27.368
37.972 27.378
37.976 27.4
37.976 28.119
37.974 28.13
37.972 28.14
37.969 28.151
37.965 28.161
37.96 28.171
37.946 28.189
37.939 28.196
37.921 28.21
37.911 28.215
37.901 28.219
37.89 28.222
37.88 28.224
37.869 28.226
37.488 28.226
37.48 28.224
37.473 28.224
37.463 28.226
16.369 28.226
END
1 25 0 N 9 1 1 100 100 0 0 0 Y
TLAYNAM B.Cu INH
5.6 19.354
5.779 19.341
5.951 19.294
6.112 19.213
6.119 19.208
6.142 19.144
5.987 18.989
5.959 19.008
5.903 19.038
5.844 19.062
5.783 19.081
5.72 19.093
5.657 19.099
5.593 19.099
5.53 19.093
5.467 19.081
5.406 19.062
5.347 19.038
5.291 19.008
5.263 18.989
5.109 19.143
5.13 19.204
5.259 19.277
5.425 19.332
5.6 19.354
END
1 25 0 N 10 1 1 100 100 0 0 0 Y
TLAYNAM B.Cu INH
6.318 18.966
6.379 18.945
6.452 18.816
6.507 18.65
6.529 18.475
6.516 18.296
6.469 18.124
6.388 17.963
6.383 17.956
6.319 17.933
6.164 18.088
6.183 18.116
6.213 18.172
6.237 18.231
6.256 18.292
6.268 18.355
6.274 18.418
6.274 18.482
6.268 18.545
6.256 18.608
6.237 18.669
6.213 18.728
6.183 18.784
6.164 18.812
6.318 18.966
END
1 25 0 N 11 1 1 100 100 0 0 0 Y
TLAYNAM B.Cu INH
6.318 11.516
6.379 11.495
6.452 11.366
6.507 11.2
6.529 11.025
6.516 10.846
6.469 10.674
6.388 10.513
6.383 10.506
6.319 10.483
6.164 10.638
6.183 10.666
6.213 10.722
6.237 10.781
6.256 10.842
6.268 10.905
6.274 10.968
6.274 11.032
6.268 11.095
6.256 11.158
6.237 11.219
6.213 11.278
6.183 11.334
6.164 11.362
6.318 11.516
END
1 25 0 N 12 1 1 100 100 0 0 0 Y
TLAYNAM B.Cu INH
5.263 10.461
5.291 10.442
5.347 10.412
5.406 10.388
5.467 10.369
5.53 10.357
5.593 10.351
5.657 10.351
5.72 10.357
5.783 10.369
5.844 10.388
5.903 10.412
5.959 10.442
5.987 10.461
6.141 10.307
6.12 10.246
5.991 10.173
5.825 10.118
5.65 10.096
5.471 10.109
5.299 10.156
5.138 10.237
5.131 10.242
5.108 10.306
5.263 10.461
END
1 39 0 N 13 1 1 100 100 0 0 0 Y
TLAYNAM B.Cu INH
7.075 15.625
7.095 15.625
7.121 15.622
7.184 15.603
7.195 15.601
7.203 15.6
7.204 15.597
7.218 15.571
7.234 15.546
7.253 15.524
7.274 15.503
7.296 15.484
7.31 15.475
7.31 15.469
7.312 15.458
7.314 15.448
7.317 15.437
7.318 15.434
7.321 15.426
7.322 15.422
7.326 15.375
7.302 15.351
7.205 15.351
7.194 15.349
7.184 15.347
7.173 15.344
7.171 15.343
7.132 15.332
7.112 15.322
7.103 15.316
7.094 15.309
7.086 15.301
7.079 15.293
7.075 15.286
7.075 15.375
6.451 15.375
6.451 15.575
7.075 15.575
7.075 15.625
END
1 41 0 N 14 1 1 100 100 0 0 0 Y
TLAYNAM B.Cu INH
7.075 14.164
7.076 14.164
7.079 14.158
7.086 14.15
7.094 14.142
7.112 14.128
7.122 14.123
7.132 14.119
7.184 14.103
7.195 14.101
7.204 14.1
7.301 14.1
7.326 14.075
7.322 14.028
7.321 14.024
7.318 14.016
7.317 14.013
7.314 14.002
7.312 13.992
7.311 13.981
7.311 13.975
7.296 13.966
7.274 13.947
7.253 13.926
7.234 13.904
7.218 13.879
7.204 13.853
7.203 13.851
7.194 13.849
7.184 13.847
7.173 13.844
7.17 13.843
7.163 13.84
7.122 13.828
7.087 13.825
7.075 13.825
7.075 13.875
6.451 13.875
6.451 14.075
7.075 14.075
7.075 14.164
END
1 46 0 N 15 1 1 100 100 0 0 0 Y
TLAYNAM B.Cu INH
7.075 15.164
7.076 15.164
7.079 15.158
7.086 15.15
7.094 15.142
7.112 15.128
7.122 15.123
7.132 15.119
7.184 15.103
7.195 15.101
7.204 15.1
7.301 15.1
7.326 15.075
7.322 15.028
7.321 15.024
7.318 15.016
7.317 15.013
7.314 15.002
7.312 14.992
7.311 14.981
7.31 14.969
7.312 14.958
7.314 14.948
7.317 14.937
7.318 14.934
7.321 14.926
7.322 14.922
7.326 14.875
7.302 14.851
7.205 14.851
7.194 14.849
7.184 14.847
7.173 14.844
7.171 14.843
7.132 14.832
7.112 14.822
7.103 14.816
7.094 14.809
7.086 14.801
7.079 14.793
7.075 14.786
7.075 14.875
6.451 14.875
6.451 15.075
7.075 15.075
7.075 15.164
END
1 46 0 N 16 1 1 100 100 0 0 0 Y
TLAYNAM B.Cu INH
7.075 14.664
7.076 14.664
7.079 14.658
7.086 14.65
7.094 14.642
7.112 14.628
7.122 14.623
7.132 14.619
7.184 14.603
7.195 14.601
7.204 14.6
7.301 14.6
7.326 14.575
7.322 14.528
7.321 14.524
7.318 14.516
7.317 14.513
7.314 14.502
7.312 14.492
7.311 14.481
7.31 14.469
7.312 14.458
7.314 14.448
7.317 14.437
7.318 14.434
7.321 14.426
7.322 14.422
7.326 14.375
7.302 14.351
7.205 14.351
7.194 14.349
7.184 14.347
7.173 14.344
7.171 14.343
7.132 14.332
7.112 14.322
7.103 14.316
7.094 14.309
7.086 14.301
7.079 14.293
7.075 14.286
7.075 14.375
6.451 14.375
6.451 14.575
7.075 14.575
7.075 14.664
END
1 48 0 N 17 1 1 100 100 0 0 0 Y
TLAYNAM B.Cu INH
5.563 15.625
5.575 15.625
5.575 15.575
6.2 15.575
6.2 15.375
5.575 15.375
5.575 15.286
5.571 15.293
5.564 15.301
5.556 15.309
5.547 15.316
5.538 15.322
5.518 15.332
5.508 15.335
5.501 15.336
5.497 15.337
5.487 15.34
5.481 15.342
5.477 15.344
5.466 15.347
5.456 15.349
5.445 15.351
5.349 15.351
5.324 15.376
5.328 15.422
5.329 15.426
5.332 15.434
5.333 15.437
5.336 15.448
5.338 15.458
5.339 15.469
5.34 15.481
5.338 15.492
5.336 15.502
5.333 15.513
5.332 15.516
5.329 15.524
5.328 15.528
5.324 15.574
5.35 15.6
5.445 15.6
5.456 15.602
5.466 15.604
5.477 15.607
5.48 15.608
5.487 15.611
5.523 15.621
5.563 15.625
END
1 48 0 N 18 1 1 100 100 0 0 0 Y
TLAYNAM B.Cu INH
5.574 14.164
5.575 14.164
5.575 14.075
6.2 14.075
6.2 13.875
5.575 13.875
5.575 13.825
5.568 13.825
5.563 13.826
5.556 13.826
5.524 13.829
5.487 13.84
5.48 13.843
5.477 13.844
5.466 13.847
5.456 13.849
5.445 13.851
5.349 13.851
5.324 13.876
5.328 13.922
5.329 13.926
5.332 13.934
5.333 13.937
5.336 13.948
5.338 13.958
5.339 13.969
5.34 13.981
5.338 13.992
5.336 14.002
5.333 14.013
5.332 14.016
5.329 14.024
5.328 14.028
5.324 14.074
5.35 14.1
5.445 14.1
5.456 14.102
5.466 14.104
5.477 14.107
5.479 14.108
5.507 14.116
5.518 14.119
5.528 14.123
5.538 14.128
5.556 14.142
5.564 14.15
5.571 14.158
5.574 14.164
END
1 49 0 N 19 1 1 100 100 0 0 0 Y
TLAYNAM B.Cu INH
5.574 15.164
5.575 15.164
5.575 15.075
6.2 15.075
6.2 14.875
5.575 14.875
5.575 14.825
5.532 14.825
5.518 14.832
5.508 14.835
5.501 14.836
5.497 14.837
5.487 14.84
5.481 14.842
5.477 14.844
5.466 14.847
5.456 14.849
5.445 14.851
5.349 14.851
5.324 14.876
5.328 14.922
5.329 14.926
5.332 14.934
5.333 14.937
5.336 14.948
5.338 14.958
5.339 14.969
5.34 14.981
5.338 14.992
5.336 15.002
5.333 15.013
5.332 15.016
5.329 15.024
5.328 15.028
5.324 15.074
5.35 15.1
5.445 15.1
5.456 15.102
5.466 15.104
5.477 15.107
5.479 15.108
5.507 15.116
5.518 15.119
5.528 15.123
5.538 15.128
5.556 15.142
5.564 15.15
5.571 15.158
5.574 15.164
END
1 49 0 N 20 1 1 100 100 0 0 0 Y
TLAYNAM B.Cu INH
5.532 14.625
5.575 14.625
5.575 14.575
6.2 14.575
6.2 14.375
5.575 14.375
5.575 14.286
5.571 14.293
5.564 14.301
5.556 14.309
5.547 14.316
5.538 14.322
5.518 14.332
5.508 14.335
5.501 14.336
5.497 14.337
5.487 14.34
5.481 14.342
5.477 14.344
5.466 14.347
5.456 14.349
5.445 14.351
5.349 14.351
5.324 14.376
5.328 14.422
5.329 14.426
5.332 14.434
5.333 14.437
5.336 14.448
5.338 14.458
5.339 14.469
5.34 14.481
5.338 14.492
5.336 14.502
5.333 14.513
5.332 14.516
5.329 14.524
5.328 14.528
5.324 14.574
5.35 14.6
5.445 14.6
5.456 14.602
5.466 14.604
5.477 14.607
5.479 14.608
5.507 14.616
5.518 14.619
5.528 14.623
5.532 14.625
END
1 22 0 N 21 1 1 100 100 0 0 0 Y
TLAYNAM B.Cu INH
43.209 3.106
42.847 2.744
42.792 2.799
42.785 2.805
42.776 2.811
42.768 2.816
42.759 2.819
42.749 2.822
42.74 2.824
42.73 2.825
42.175 2.825
42.175 2.975
41.675 2.975
41.675 2.475
42.175 2.475
42.175 2.625
42.684 2.625
42.706 2.603
42.219 2.116
44.241 0.094
45.231 1.084
43.209 3.106
END
VIA POLYGON
1 5 -1 N 22 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
1.201 14.869
1.201 14.619
1.451 14.619
1.451 14.869
1.201 14.869
END
VIA POLYGON
1 5 -1 N 23 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
3.85 14.85
3.85 14.6
4.1 14.6
4.1 14.85
3.85 14.85
END
VIA POLYGON
1 5 -1 N 24 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
4.85 14.85
4.85 14.6
5.1 14.6
5.1 14.85
4.85 14.85
END
VIA POLYGON
1 5 -1 N 25 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
21.35 3.35
21.35 3.1
21.6 3.1
21.6 3.35
21.35 3.35
END
VIA POLYGON
1 5 -1 N 26 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
22.35 3.35
22.35 3.1
22.6 3.1
22.6 3.35
22.35 3.35
END
VIA POLYGON
1 5 -1 N 27 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
23.35 3.35
23.35 3.1
23.6 3.1
23.6 3.35
23.35 3.35
END
VIA POLYGON
1 5 -1 N 28 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
24.35 3.35
24.35 3.1
24.6 3.1
24.6 3.35
24.35 3.35
END
VIA POLYGON
1 5 -1 N 29 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
25.35 3.35
25.35 3.1
25.6 3.1
25.6 3.35
25.35 3.35
END
VIA POLYGON
1 5 -1 N 30 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
26.35 3.35
26.35 3.1
26.6 3.1
26.6 3.35
26.35 3.35
END
VIA POLYGON
1 5 -1 N 31 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
27.35 3.35
27.35 3.1
27.6 3.1
27.6 3.35
27.35 3.35
END
VIA POLYGON
1 5 -1 N 32 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
28.35 3.35
28.35 3.1
28.6 3.1
28.6 3.35
28.35 3.35
END
VIA POLYGON
1 5 -1 N 33 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
29.35 3.35
29.35 3.1
29.6 3.1
29.6 3.35
29.35 3.35
END
VIA POLYGON
1 5 -1 N 34 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
30.35 3.35
30.35 3.1
30.6 3.1
30.6 3.35
30.35 3.35
END
VIA POLYGON
1 5 -1 N 35 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
31.35 3.35
31.35 3.1
31.6 3.1
31.6 3.35
31.35 3.35
END
VIA POLYGON
1 5 -1 N 36 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
32.35 3.35
32.35 3.1
32.6 3.1
32.6 3.35
32.35 3.35
END
VIA POLYGON
1 5 -1 N 37 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
33.35 3.35
33.35 3.1
33.6 3.1
33.6 3.35
33.35 3.35
END
VIA POLYGON
1 5 -1 N 38 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
34.35 3.35
34.35 3.1
34.6 3.1
34.6 3.35
34.35 3.35
END
VIA POLYGON
1 5 -1 N 39 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
35.35 3.35
35.35 3.1
35.6 3.1
35.6 3.35
35.35 3.35
END
VIA POLYGON
1 5 -1 N 40 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
36.35 3.35
36.35 3.1
36.6 3.1
36.6 3.35
36.35 3.35
END
VIA POLYGON
1 5 -1 N 41 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
37.35 3.35
37.35 3.1
37.6 3.1
37.6 3.35
37.35 3.35
END
VIA POLYGON
1 5 -1 N 42 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
21.35 1.85
21.35 1.6
21.6 1.6
21.6 1.85
21.35 1.85
END
VIA POLYGON
1 5 -1 N 43 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
22.35 1.85
22.35 1.6
22.6 1.6
22.6 1.85
22.35 1.85
END
VIA POLYGON
1 5 -1 N 44 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
23.35 1.85
23.35 1.6
23.6 1.6
23.6 1.85
23.35 1.85
END
VIA POLYGON
1 5 -1 N 45 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
24.35 1.85
24.35 1.6
24.6 1.6
24.6 1.85
24.35 1.85
END
VIA POLYGON
1 5 -1 N 46 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
25.35 1.85
25.35 1.6
25.6 1.6
25.6 1.85
25.35 1.85
END
VIA POLYGON
1 5 -1 N 47 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
26.35 1.85
26.35 1.6
26.6 1.6
26.6 1.85
26.35 1.85
END
VIA POLYGON
1 5 -1 N 48 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
27.35 1.85
27.35 1.6
27.6 1.6
27.6 1.85
27.35 1.85
END
VIA POLYGON
1 5 -1 N 49 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
28.35 1.85
28.35 1.6
28.6 1.6
28.6 1.85
28.35 1.85
END
VIA POLYGON
1 5 -1 N 50 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
29.35 1.85
29.35 1.6
29.6 1.6
29.6 1.85
29.35 1.85
END
VIA POLYGON
1 5 -1 N 51 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
30.35 1.85
30.35 1.6
30.6 1.6
30.6 1.85
30.35 1.85
END
VIA POLYGON
1 5 -1 N 52 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
31.35 1.85
31.35 1.6
31.6 1.6
31.6 1.85
31.35 1.85
END
VIA POLYGON
1 5 -1 N 53 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
32.35 1.85
32.35 1.6
32.6 1.6
32.6 1.85
32.35 1.85
END
VIA POLYGON
1 5 -1 N 54 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
33.35 1.85
33.35 1.6
33.6 1.6
33.6 1.85
33.35 1.85
END
VIA POLYGON
1 5 -1 N 55 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
34.35 1.85
34.35 1.6
34.6 1.6
34.6 1.85
34.35 1.85
END
VIA POLYGON
1 5 -1 N 56 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
35.35 1.85
35.35 1.6
35.6 1.6
35.6 1.85
35.35 1.85
END
VIA POLYGON
1 5 -1 N 57 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
36.35 1.85
36.35 1.6
36.6 1.6
36.6 1.85
36.35 1.85
END
VIA POLYGON
1 5 -1 N 58 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
37.35 1.85
37.35 1.6
37.6 1.6
37.6 1.85
37.35 1.85
END
VIA POLYGON
1 5 -1 N 61 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
15.35 10.35
15.35 10.1
15.6 10.1
15.6 10.35
15.35 10.35
END
VIA POLYGON
1 5 -1 N 62 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
16.85 10.35
16.85 10.1
17.1 10.1
17.1 10.35
16.85 10.35
END
VIA POLYGON
1 5 -1 N 63 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
15.35 9.35
15.35 9.1
15.6 9.1
15.6 9.35
15.35 9.35
END
VIA POLYGON
1 5 -1 N 64 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
16.85 9.35
16.85 9.1
17.1 9.1
17.1 9.35
16.85 9.35
END
VIA POLYGON
1 5 -1 N 65 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
15.35 8.35
15.35 8.1
15.6 8.1
15.6 8.35
15.35 8.35
END
VIA POLYGON
1 5 -1 N 66 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
16.85 8.35
16.85 8.1
17.1 8.1
17.1 8.35
16.85 8.35
END
VIA POLYGON
1 5 -1 N 67 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
15.35 7.35
15.35 7.1
15.6 7.1
15.6 7.35
15.35 7.35
END
VIA POLYGON
1 5 -1 N 68 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
16.85 7.35
16.85 7.1
17.1 7.1
17.1 7.35
16.85 7.35
END
VIA POLYGON
1 5 -1 N 69 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
15.35 6.35
15.35 6.1
15.6 6.1
15.6 6.35
15.35 6.35
END
VIA POLYGON
1 5 -1 N 70 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
16.85 6.35
16.85 6.1
17.1 6.1
17.1 6.35
16.85 6.35
END
VIA POLYGON
1 5 -1 N 71 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
15.35 5.35
15.35 5.1
15.6 5.1
15.6 5.35
15.35 5.35
END
VIA POLYGON
1 5 -1 N 72 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
16.85 5.35
16.85 5.1
17.1 5.1
17.1 5.35
16.85 5.35
END
VIA POLYGON
1 5 -1 N 73 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
15.35 4.35
15.35 4.1
15.6 4.1
15.6 4.35
15.35 4.35
END
VIA POLYGON
1 5 -1 N 74 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
16.85 4.35
16.85 4.1
17.1 4.1
17.1 4.35
16.85 4.35
END
VIA POLYGON
1 5 -1 N 75 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
17.35 3.35
17.35 3.1
17.6 3.1
17.6 3.35
17.35 3.35
END
VIA POLYGON
1 5 -1 N 76 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
18.35 3.35
18.35 3.1
18.6 3.1
18.6 3.35
18.35 3.35
END
VIA POLYGON
1 5 -1 N 77 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
19.35 3.35
19.35 3.1
19.6 3.1
19.6 3.35
19.35 3.35
END
VIA POLYGON
1 5 -1 N 78 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
20.35 3.35
20.35 3.1
20.6 3.1
20.6 3.35
20.35 3.35
END
VIA POLYGON
1 5 -1 N 79 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
0.4 14.35
0.4 14.1
0.65 14.1
0.65 14.35
0.4 14.35
END
VIA POLYGON
1 5 -1 N 80 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
4.85 13.85
4.85 13.6
5.1 13.6
5.1 13.85
4.85 13.85
END
VIA POLYGON
1 5 -1 N 81 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
7.35 13.85
7.35 13.6
7.6 13.6
7.6 13.85
7.35 13.85
END
VIA POLYGON
1 5 -1 N 82 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
8.35 13.85
8.35 13.6
8.6 13.6
8.6 13.85
8.35 13.85
END
VIA POLYGON
1 5 -1 N 83 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
9.35 13.85
9.35 13.6
9.6 13.6
9.6 13.85
9.35 13.85
END
VIA POLYGON
1 5 -1 N 84 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
10.35 13.85
10.35 13.6
10.6 13.6
10.6 13.85
10.35 13.85
END
VIA POLYGON
1 5 -1 N 85 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
11.35 13.85
11.35 13.6
11.6 13.6
11.6 13.85
11.35 13.85
END
VIA POLYGON
1 5 -1 N 86 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
12.35 13.85
12.35 13.6
12.6 13.6
12.6 13.85
12.35 13.85
END
VIA POLYGON
1 5 -1 N 87 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
13.35 13.85
13.35 13.6
13.6 13.6
13.6 13.85
13.35 13.85
END
VIA POLYGON
1 5 -1 N 88 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
14.35 13.85
14.35 13.6
14.6 13.6
14.6 13.85
14.35 13.85
END
VIA POLYGON
1 5 -1 N 89 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
15.35 13.85
15.35 13.6
15.6 13.6
15.6 13.85
15.35 13.85
END
VIA POLYGON
1 5 -1 N 90 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
0.4 13.35
0.4 13.1
0.65 13.1
0.65 13.35
0.4 13.35
END
VIA POLYGON
1 5 -1 N 91 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
16.35 13.35
16.35 13.1
16.6 13.1
16.6 13.35
16.35 13.35
END
VIA POLYGON
1 5 -1 N 92 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
1.85 12.85
1.85 12.6
2.1 12.6
2.1 12.85
1.85 12.85
END
VIA POLYGON
1 5 -1 N 93 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
0.4 12.35
0.4 12.1
0.65 12.1
0.65 12.35
0.4 12.35
END
VIA POLYGON
1 5 -1 N 94 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
6.35 12.35
6.35 12.1
6.6 12.1
6.6 12.35
6.35 12.35
END
VIA POLYGON
1 5 -1 N 95 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
7.35 12.35
7.35 12.1
7.6 12.1
7.6 12.35
7.35 12.35
END
VIA POLYGON
1 5 -1 N 96 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
15.725 2.975
15.725 2.725
15.975 2.725
15.975 2.975
15.725 2.975
END
VIA POLYGON
1 5 -1 N 97 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
16.35 2.35
16.35 2.1
16.6 2.1
16.6 2.35
16.35 2.35
END
VIA POLYGON
1 5 -1 N 98 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
17.35 1.85
17.35 1.6
17.6 1.6
17.6 1.85
17.35 1.85
END
VIA POLYGON
1 5 -1 N 99 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
18.35 1.85
18.35 1.6
18.6 1.6
18.6 1.85
18.35 1.85
END
VIA POLYGON
1 5 -1 N 100 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
19.35 1.85
19.35 1.6
19.6 1.6
19.6 1.85
19.35 1.85
END
VIA POLYGON
1 5 -1 N 101 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
20.35 1.85
20.35 1.6
20.6 1.6
20.6 1.85
20.35 1.85
END
VIA POLYGON
1 5 -1 N 102 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
8.35 12.35
8.35 12.1
8.6 12.1
8.6 12.35
8.35 12.35
END
VIA POLYGON
1 5 -1 N 103 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
9.35 12.35
9.35 12.1
9.6 12.1
9.6 12.35
9.35 12.35
END
VIA POLYGON
1 5 -1 N 104 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
10.35 12.35
10.35 12.1
10.6 12.1
10.6 12.35
10.35 12.35
END
VIA POLYGON
1 5 -1 N 105 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
11.35 12.35
11.35 12.1
11.6 12.1
11.6 12.35
11.35 12.35
END
VIA POLYGON
1 5 -1 N 106 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
12.35 12.35
12.35 12.1
12.6 12.1
12.6 12.35
12.35 12.35
END
VIA POLYGON
1 5 -1 N 107 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
13.35 12.35
13.35 12.1
13.6 12.1
13.6 12.35
13.35 12.35
END
VIA POLYGON
1 5 -1 N 108 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
14.35 12.35
14.35 12.1
14.6 12.1
14.6 12.35
14.35 12.35
END
VIA POLYGON
1 5 -1 N 109 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
15.35 12.35
15.35 12.1
15.6 12.1
15.6 12.35
15.35 12.35
END
VIA POLYGON
1 5 -1 N 110 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
16.85 12.35
16.85 12.1
17.1 12.1
17.1 12.35
16.85 12.35
END
VIA POLYGON
1 5 -1 N 111 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
2.9 13.2
2.9 11.75
4.35 11.75
4.35 13.2
2.9 13.2
END
VIA POLYGON
1 5 -1 N 112 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
2.54 11.8
2.54 11.55
2.79 11.55
2.79 11.8
2.54 11.8
END
VIA POLYGON
1 5 -1 N 113 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
0.85 11.35
0.85 11.1
1.1 11.1
1.1 11.35
0.85 11.35
END
VIA POLYGON
1 5 -1 N 114 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
15.35 11.35
15.35 11.1
15.6 11.1
15.6 11.35
15.35 11.35
END
VIA POLYGON
1 5 -1 N 115 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
16.85 11.35
16.85 11.1
17.1 11.1
17.1 11.35
16.85 11.35
END
VIA POLYGON
1 5 -1 N 116 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
1.35 10.85
1.35 10.6
1.6 10.6
1.6 10.85
1.35 10.85
END
VIA POLYGON
1 5 -1 N 117 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
5.125 11.5
5.125 10.5
6.125 10.5
6.125 11.5
5.125 11.5
END
VIA POLYGON
1 5 -1 N 118 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
2.35 10.35
2.35 10.1
2.6 10.1
2.6 10.35
2.35 10.35
END
VIA POLYGON
1 5 -1 N 119 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
3.35 10.35
3.35 10.1
3.6 10.1
3.6 10.35
3.35 10.35
END
VIA POLYGON
1 5 -1 N 120 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
4.35 10.35
4.35 10.1
4.6 10.1
4.6 10.35
4.35 10.35
END
VIA POLYGON
1 5 -1 N 121 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
9.35 17.35
9.35 17.1
9.6 17.1
9.6 17.35
9.35 17.35
END
VIA POLYGON
1 5 -1 N 122 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
10.35 17.35
10.35 17.1
10.6 17.1
10.6 17.35
10.35 17.35
END
VIA POLYGON
1 5 -1 N 123 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
11.35 17.35
11.35 17.1
11.6 17.1
11.6 17.35
11.35 17.35
END
VIA POLYGON
1 5 -1 N 124 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
12.35 17.35
12.35 17.1
12.6 17.1
12.6 17.35
12.35 17.35
END
VIA POLYGON
1 5 -1 N 125 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
13.35 17.35
13.35 17.1
13.6 17.1
13.6 17.35
13.35 17.35
END
VIA POLYGON
1 5 -1 N 126 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
14.35 17.35
14.35 17.1
14.6 17.1
14.6 17.35
14.35 17.35
END
VIA POLYGON
1 5 -1 N 127 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
15.35 17.35
15.35 17.1
15.6 17.1
15.6 17.35
15.35 17.35
END
VIA POLYGON
1 5 -1 N 128 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
16.85 17.35
16.85 17.1
17.1 17.1
17.1 17.35
16.85 17.35
END
VIA POLYGON
1 5 -1 N 129 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
1.85 16.85
1.85 16.6
2.1 16.6
2.1 16.85
1.85 16.85
END
VIA POLYGON
1 5 -1 N 130 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
2.9 17.7
2.9 16.25
4.35 16.25
4.35 17.7
2.9 17.7
END
VIA POLYGON
1 5 -1 N 131 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
0.4 16.35
0.4 16.1
0.65 16.1
0.65 16.35
0.4 16.35
END
VIA POLYGON
1 5 -1 N 132 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
16.35 16.35
16.35 16.1
16.6 16.1
16.6 16.35
16.35 16.35
END
VIA POLYGON
1 5 -1 N 133 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
4.85 15.85
4.85 15.6
5.1 15.6
5.1 15.85
4.85 15.85
END
VIA POLYGON
1 5 -1 N 134 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
7.35 15.85
7.35 15.6
7.6 15.6
7.6 15.85
7.35 15.85
END
VIA POLYGON
1 5 -1 N 135 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
8.35 15.85
8.35 15.6
8.6 15.6
8.6 15.85
8.35 15.85
END
VIA POLYGON
1 5 -1 N 136 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
9.35 15.85
9.35 15.6
9.6 15.6
9.6 15.85
9.35 15.85
END
VIA POLYGON
1 5 -1 N 137 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
10.35 15.85
10.35 15.6
10.6 15.6
10.6 15.85
10.35 15.85
END
VIA POLYGON
1 5 -1 N 138 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
11.35 15.85
11.35 15.6
11.6 15.6
11.6 15.85
11.35 15.85
END
VIA POLYGON
1 5 -1 N 139 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
12.35 15.85
12.35 15.6
12.6 15.6
12.6 15.85
12.35 15.85
END
VIA POLYGON
1 5 -1 N 140 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
13.35 15.85
13.35 15.6
13.6 15.6
13.6 15.85
13.35 15.85
END
VIA POLYGON
1 5 -1 N 141 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
14.35 15.85
14.35 15.6
14.6 15.6
14.6 15.85
14.35 15.85
END
VIA POLYGON
1 5 -1 N 142 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
15.35 15.85
15.35 15.6
15.6 15.6
15.6 15.85
15.35 15.85
END
VIA POLYGON
1 5 -1 N 143 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
0.4 15.35
0.4 15.1
0.65 15.1
0.65 15.35
0.4 15.35
END
VIA POLYGON
1 5 -1 N 144 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
16.35 27.85
16.35 27.6
16.6 27.6
16.6 27.85
16.35 27.85
END
VIA POLYGON
1 5 -1 N 145 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
17.35 27.85
17.35 27.6
17.6 27.6
17.6 27.85
17.35 27.85
END
VIA POLYGON
1 5 -1 N 146 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
18.35 27.85
18.35 27.6
18.6 27.6
18.6 27.85
18.35 27.85
END
VIA POLYGON
1 5 -1 N 147 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
19.35 27.85
19.35 27.6
19.6 27.6
19.6 27.85
19.35 27.85
END
VIA POLYGON
1 5 -1 N 148 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
20.35 27.85
20.35 27.6
20.6 27.6
20.6 27.85
20.35 27.85
END
VIA POLYGON
1 5 -1 N 149 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
15.725 27.225
15.725 26.975
15.975 26.975
15.975 27.225
15.725 27.225
END
VIA POLYGON
1 5 -1 N 150 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
15.35 26.6
15.35 26.35
15.6 26.35
15.6 26.6
15.35 26.6
END
VIA POLYGON
1 5 -1 N 151 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
17.35 26.35
17.35 26.1
17.6 26.1
17.6 26.35
17.35 26.35
END
VIA POLYGON
1 5 -1 N 152 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
18.35 26.35
18.35 26.1
18.6 26.1
18.6 26.35
18.35 26.35
END
VIA POLYGON
1 5 -1 N 153 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
19.35 26.35
19.35 26.1
19.6 26.1
19.6 26.35
19.35 26.35
END
VIA POLYGON
1 5 -1 N 154 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
20.35 26.35
20.35 26.1
20.6 26.1
20.6 26.35
20.35 26.35
END
VIA POLYGON
1 5 -1 N 155 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
15.35 25.35
15.35 25.1
15.6 25.1
15.6 25.35
15.35 25.35
END
VIA POLYGON
1 5 -1 N 156 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
16.85 25.35
16.85 25.1
17.1 25.1
17.1 25.35
16.85 25.35
END
VIA POLYGON
1 5 -1 N 157 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
15.35 24.35
15.35 24.1
15.6 24.1
15.6 24.35
15.35 24.35
END
VIA POLYGON
1 5 -1 N 158 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
16.85 24.35
16.85 24.1
17.1 24.1
17.1 24.35
16.85 24.35
END
VIA POLYGON
1 5 -1 N 159 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
15.35 23.35
15.35 23.1
15.6 23.1
15.6 23.35
15.35 23.35
END
VIA POLYGON
1 5 -1 N 160 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
16.85 23.35
16.85 23.1
17.1 23.1
17.1 23.35
16.85 23.35
END
VIA POLYGON
1 5 -1 N 161 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
15.35 22.35
15.35 22.1
15.6 22.1
15.6 22.35
15.35 22.35
END
VIA POLYGON
1 5 -1 N 162 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
16.85 22.35
16.85 22.1
17.1 22.1
17.1 22.35
16.85 22.35
END
VIA POLYGON
1 5 -1 N 163 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
15.35 21.35
15.35 21.1
15.6 21.1
15.6 21.35
15.35 21.35
END
VIA POLYGON
1 5 -1 N 164 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
16.85 21.35
16.85 21.1
17.1 21.1
17.1 21.35
16.85 21.35
END
VIA POLYGON
1 5 -1 N 165 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
15.35 20.35
15.35 20.1
15.6 20.1
15.6 20.35
15.35 20.35
END
VIA POLYGON
1 5 -1 N 166 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
16.85 20.35
16.85 20.1
17.1 20.1
17.1 20.35
16.85 20.35
END
VIA POLYGON
1 5 -1 N 167 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
2.35 19.35
2.35 19.1
2.6 19.1
2.6 19.35
2.35 19.35
END
VIA POLYGON
1 5 -1 N 168 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
3.35 19.35
3.35 19.1
3.6 19.1
3.6 19.35
3.35 19.35
END
VIA POLYGON
1 5 -1 N 169 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
4.35 19.35
4.35 19.1
4.6 19.1
4.6 19.35
4.35 19.35
END
VIA POLYGON
1 5 -1 N 170 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
15.35 19.35
15.35 19.1
15.6 19.1
15.6 19.35
15.35 19.35
END
VIA POLYGON
1 5 -1 N 171 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
16.85 19.35
16.85 19.1
17.1 19.1
17.1 19.35
16.85 19.35
END
VIA POLYGON
1 5 -1 N 172 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
1.35 18.85
1.35 18.6
1.6 18.6
1.6 18.85
1.35 18.85
END
VIA POLYGON
1 5 -1 N 173 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
0.85 18.35
0.85 18.1
1.1 18.1
1.1 18.35
0.85 18.35
END
VIA POLYGON
1 5 -1 N 174 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
15.35 18.35
15.35 18.1
15.6 18.1
15.6 18.35
15.35 18.35
END
VIA POLYGON
1 5 -1 N 175 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
16.85 18.35
16.85 18.1
17.1 18.1
17.1 18.35
16.85 18.35
END
VIA POLYGON
1 5 -1 N 176 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
5.125 18.95
5.125 17.95
6.125 17.95
6.125 18.95
5.125 18.95
END
VIA POLYGON
1 5 -1 N 177 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
2.54 17.9
2.54 17.65
2.79 17.65
2.79 17.9
2.54 17.9
END
VIA POLYGON
1 5 -1 N 178 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
0.4 17.35
0.4 17.1
0.65 17.1
0.65 17.35
0.4 17.35
END
VIA POLYGON
1 5 -1 N 179 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
6.35 17.35
6.35 17.1
6.6 17.1
6.6 17.35
6.35 17.35
END
VIA POLYGON
1 5 -1 N 180 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
7.35 17.35
7.35 17.1
7.6 17.1
7.6 17.35
7.35 17.35
END
VIA POLYGON
1 5 -1 N 181 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
8.35 17.35
8.35 17.1
8.6 17.1
8.6 17.35
8.35 17.35
END
VIA POLYGON
1 5 -1 N 182 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
30.35 27.85
30.35 27.6
30.6 27.6
30.6 27.85
30.35 27.85
END
VIA POLYGON
1 5 -1 N 183 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
31.35 27.85
31.35 27.6
31.6 27.6
31.6 27.85
31.35 27.85
END
VIA POLYGON
1 5 -1 N 184 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
32.35 27.85
32.35 27.6
32.6 27.6
32.6 27.85
32.35 27.85
END
VIA POLYGON
1 5 -1 N 185 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
33.35 27.85
33.35 27.6
33.6 27.6
33.6 27.85
33.35 27.85
END
VIA POLYGON
1 5 -1 N 186 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
34.35 27.85
34.35 27.6
34.6 27.6
34.6 27.85
34.35 27.85
END
VIA POLYGON
1 5 -1 N 187 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
35.35 27.85
35.35 27.6
35.6 27.6
35.6 27.85
35.35 27.85
END
VIA POLYGON
1 5 -1 N 188 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
36.35 27.85
36.35 27.6
36.6 27.6
36.6 27.85
36.35 27.85
END
VIA POLYGON
1 5 -1 N 189 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
37.35 27.85
37.35 27.6
37.6 27.6
37.6 27.85
37.35 27.85
END
VIA POLYGON
1 5 -1 N 192 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
21.35 27.85
21.35 27.6
21.6 27.6
21.6 27.85
21.35 27.85
END
VIA POLYGON
1 5 -1 N 193 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
22.35 27.85
22.35 27.6
22.6 27.6
22.6 27.85
22.35 27.85
END
VIA POLYGON
1 5 -1 N 194 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
23.35 27.85
23.35 27.6
23.6 27.6
23.6 27.85
23.35 27.85
END
VIA POLYGON
1 5 -1 N 195 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
24.35 27.85
24.35 27.6
24.6 27.6
24.6 27.85
24.35 27.85
END
VIA POLYGON
1 5 -1 N 196 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
21.35 26.35
21.35 26.1
21.6 26.1
21.6 26.35
21.35 26.35
END
VIA POLYGON
1 5 -1 N 197 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
22.35 26.35
22.35 26.1
22.6 26.1
22.6 26.35
22.35 26.35
END
VIA POLYGON
1 5 -1 N 198 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
23.35 26.35
23.35 26.1
23.6 26.1
23.6 26.35
23.35 26.35
END
VIA POLYGON
1 5 -1 N 199 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
24.35 26.35
24.35 26.1
24.6 26.1
24.6 26.35
24.35 26.35
END
VIA POLYGON
1 5 -1 N 200 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
25.35 26.35
25.35 26.1
25.6 26.1
25.6 26.35
25.35 26.35
END
VIA POLYGON
1 5 -1 N 201 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
26.35 26.35
26.35 26.1
26.6 26.1
26.6 26.35
26.35 26.35
END
VIA POLYGON
1 5 -1 N 202 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
27.35 26.35
27.35 26.1
27.6 26.1
27.6 26.35
27.35 26.35
END
VIA POLYGON
1 5 -1 N 203 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
28.35 26.35
28.35 26.1
28.6 26.1
28.6 26.35
28.35 26.35
END
VIA POLYGON
1 5 -1 N 204 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
29.35 26.35
29.35 26.1
29.6 26.1
29.6 26.35
29.35 26.35
END
VIA POLYGON
1 5 -1 N 205 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
30.35 26.35
30.35 26.1
30.6 26.1
30.6 26.35
30.35 26.35
END
VIA POLYGON
1 5 -1 N 206 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
31.35 26.35
31.35 26.1
31.6 26.1
31.6 26.35
31.35 26.35
END
VIA POLYGON
1 5 -1 N 207 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
32.35 26.35
32.35 26.1
32.6 26.1
32.6 26.35
32.35 26.35
END
VIA POLYGON
1 5 -1 N 208 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
33.35 26.35
33.35 26.1
33.6 26.1
33.6 26.35
33.35 26.35
END
VIA POLYGON
1 5 -1 N 209 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
34.35 26.35
34.35 26.1
34.6 26.1
34.6 26.35
34.35 26.35
END
VIA POLYGON
1 5 -1 N 210 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
35.35 26.35
35.35 26.1
35.6 26.1
35.6 26.35
35.35 26.35
END
VIA POLYGON
1 5 -1 N 211 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
36.35 26.35
36.35 26.1
36.6 26.1
36.6 26.35
36.35 26.35
END
VIA POLYGON
1 5 -1 N 212 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
37.35 26.35
37.35 26.1
37.6 26.1
37.6 26.35
37.35 26.35
END
VIA POLYGON
1 5 -1 N 213 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
25.35 27.85
25.35 27.6
25.6 27.6
25.6 27.85
25.35 27.85
END
VIA POLYGON
1 5 -1 N 214 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
26.35 27.85
26.35 27.6
26.6 27.6
26.6 27.85
26.35 27.85
END
VIA POLYGON
1 5 -1 N 215 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
27.35 27.85
27.35 27.6
27.6 27.6
27.6 27.85
27.35 27.85
END
VIA POLYGON
1 5 -1 N 216 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
28.35 27.85
28.35 27.6
28.6 27.6
28.6 27.85
28.35 27.85
END
VIA POLYGON
1 5 -1 N 217 1 1 100 100 0 0 0 Y
TOLEVEL 2 RING NOCOVERS
TLAYNAM Via1 INH
29.35 27.85
29.35 27.6
29.6 27.6
29.6 27.85
29.35 27.85
END
END GEO
OPT
MAX 100
END OPT
VARSWP
END VARSWP
```
